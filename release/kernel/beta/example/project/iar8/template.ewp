# IAR project template.ewp, settings and files
configuration template_armv6_m (ARM, debug)
  General.OGChipSelectEditMenu: CortexM0MPS2FVP Cortex-M0 MPS2 FVP
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CMSDK_CM0
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866,Pe177
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\..\vsf; ..\..\usrapp\template; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM0\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration template_armv7_m (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CortexM7MPS2FVP Cortex-M7 MPS2 FVP
  General.CoreVariant: 41
  ICCARM.CCDefines: CMSDK_CM7
  ICCARM.CCIncludePath2: ..\..\..\vsf; ..\..\usrapp\template; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM7\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\
  group user_application
    ../../usrapp/template/: main_fsm_simple.c main_full_feature_demo.c main_pt_simple.c main_task_simple.c main_thread_simple.c user_retarget.c vsf_app_cfg.h
  group vsf/kernel
    ../../../vsf/kernel/: vsf_kernel_bsp.c
  group vsf/kernel/lib
    ../../../vsf/kernel/lib/: vsf_kernel_armv6m_full_size.a vsf_kernel_armv7m_full_size.a
  group vsf/kernel/shell/simple
    ../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmevt.h
  group vsf/kernel/task
    ../../../vsf/kernel/task/: vsf_fsm.h vsf_pt.h vsf_task.h vsf_thread.h
