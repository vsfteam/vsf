# Keil uVision project Blinky.uvprojx, settings and files
target template_armv7-m_ac6 (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER
  c misc: -fms-extensions -Wno-empty-body -Wno-initializer-overrides -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\..\vsf;..\..\usrapp\template;..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include;..\..\usrapp\template\app_cfg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
  group configuration
    ../../usrapp/template/app_cfg/: app_cfg.h vsf_usr_cfg.h
  group source
    ../../usrapp/template/: main_thread_simple.c main_task_simple.c main_fsm_simple.c main_cross_task_example.c
  group vsf/kernel/shell/simple
    ../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmevt.h
  group vsf/kernel
    ../../../vsf/kernel/: vsf_kernel_bsp.c
    ../../../vsf/kernel/lib/: vsf_kernel_armv6m_full_size.a vsf_kernel_armv7m_full_size.a vsf_kernel_armv7em_full_size.a
    ../../../vsf/hal/arch/: vsf_arch.c
  group vsf/kernel/task
    ../../../vsf/kernel/task/: vsf_pt.h vsf_task.h vsf_thread.h vsf_fsm.h
  group bsp
    ../../usrapp/template/: user_retarget.c
    ../../../vsf/utilities/compiler/arm/: vsf_stdio_lib.a
target template_armv6-m_ac6 (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: as above
  c define: _MSC_VER
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target template_armv6-m_ac5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c misc: --diag_suppress=64,1,381,177,111 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target tempalte_armv7-m_ac5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=64,1,381,177,111 --wchar32
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
software components: CMSIS:CORE 5.2.0, Board Support:Common 2.0.0, Device:Startup 1.0.0, Device:Startup 1.0.0
