# Keil uVision project Blinky.uvprojx, settings and files
target demo_armv7-m-ac6 (6150000::V6.15::ARMCLANG)
  device: CMSDK_CM7 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER, __ARM__, __MPS2__, LV_CONF_INCLUDE_SIMPLE
  c misc: -fms-extensions  -Wno-enum-conversion -Wno-empty-body  -Wno-initializer-overrides -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\config;..\..\..\..\source;..\..\..\..\source\shell\sys\linux\include;..\..\..\..\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include;..\..\..\..\source\component\3rd-party\lvgl\raw;..\..\..\..\source\component\3rd-party\segger_rtt\raw
  asm misc: --cpreproc --cpreproc_opts=-D_MSC_VER,-D__ARM__,-D__MPS2__
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
  group usrapp/config
    ../../config/: awtk_config.h btstack_config.h lv_conf.h vsf_tgui_cfg.h vsf_tgui_designer_cfg.h vsf_usr_cfg.h
  group usrapp/config/vsf_usr_cfg
    ../../config/vsf_usr_cfg/: vsf_usr_cfg_f1c100s.h vsf_usr_cfg_mps2.h
  group demo
    ../../demo/: fakefat32.c fakefat32.h
  group demo/audio_demo
    ../../demo/audio_demo/: audio_demo.c
  group demo/awtk_demo
    ../../demo/awtk_demo/: awtk_application.c awtk_assets.c awtk_demo.c
  group demo/btstack_demo
    ../../demo/btstack_demo/: btstack_application.c btstack_demo.c
  group demo/common
    ../../demo/common/: usrapp_audio_common.c usrapp_audio_common.h usrapp_common.c usrapp_common.h usrapp_net_common.c usrapp_net_common.h usrapp_ui_common.c usrapp_ui_common.h usrapp_usbd_common.c usrapp_usbd_common.h usrapp_usbh_common.c usrapp_usbh_common.h
  group demo/evm_demo
    ../../demo/evm_demo/: evm_demo.c evm_module.c
  group demo/freetype_demo
    ../../demo/freetype_demo/: freetype_demo.c
  group demo/gato_demo
    ../../demo/gato_demo/: gato_application.c gato_demo.c
  group demo/hal_demo
    ../../demo/hal_demo/: usart_demo.c
  group demo/json_demo
    ../../demo/json_demo/: json_demo.c
  group demo/kernel_test
    ../../demo/kernel_test/: sem_test.c user_retarget.c
  group demo/linux_demo
    ../../demo/linux_demo/: libusb_demo.c linux_demo.c mount_file_demo.c
  group demo/lvgl_demo
    ../../demo/lvgl_demo/: lvgl_application.c lvgl_demo.c
  group demo/lwip_demo
    ../../demo/lwip_demo/: lwip_demo.c
  group demo/nnom_demo
    ../../demo/nnom_demo/: nnom_demo.c
  group demo/nuklear_demo
    ../../demo/nuklear_demo/: main.c sdl2surface_rawfb.h
  group demo/scsi_demo
    ../../demo/scsi_demo/: scsi_demo.c
  group demo/socket_demo
    ../../demo/socket_demo/: socket_demo.c
  group demo/stream_hal_demo
    ../../demo/stream_hal_demo/: stream_usart_demo.c
  group demo/tgui_demo
    ../../demo/tgui_demo/tgui_demo/: tgui_custom.c tgui_custom.h tgui_demo.c tgui_port.c
    ../../demo/tgui_demo/: tgui_main.c
  group demo/tgui_demo/images
    ../../demo/tgui_demo/tgui_demo/images/: demo_images.c demo_images.h demo_images_data.h
  group demo/tgui_demo/stopwatch
    ../../demo/tgui_demo/tgui_demo/stopwatch/: stopwatch.c stopwatch.h
  group demo/tgui_demo/tgui_designer
    ../../demo/tgui_demo/tgui_demo/tgui_designer/: tgui_control_create.c tgui_control_create.h tgui_control_tree_dump.c tgui_control_tree_dump.h tgui_designer.c tgui_designer.h tgui_designer_common.c tgui_designer_common.h
  group demo/usbd_demo
    ../../demo/usbd_demo/: usbd_demo_cdc.c usbd_demo_msc.c usbd_demo_uac.c usbd_demo_user.c usbd_demo_uvc.c
  group demo/vsfip_demo
    ../../demo/vsfip_demo/: vsfip_demo.c
  group demo/vsfvm_demo
    ../../demo/vsfvm_demo/: vsfvm_demo.c
  group demo/xui_demo
    ../../demo/xui_demo/: xui_demo.c
  group vsf
    ../../../../source/: vsf.h vsf_cfg.h
  group vsf/component
    ../../../../source/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/3rd-party/evm/extension/usbh
    ../../../../source/component/3rd-party/evm/extension/usbh/: evm_module_usbh.c evm_module_usbh.h
  group vsf/component/3rd-party/evm/port
    ../../../../source/component/3rd-party/evm/port/: evm_main.c
  group vsf/component/3rd-party/gato/raw/examples
    ../../../../source/component/3rd-party/gato/raw/examples/: dock.c example_1.c example_2.c example_3.c example_4.c main.c ui.c
  group vsf/component/3rd-party/gato/raw/image
    ../../../../source/component/3rd-party/gato/raw/image/: image.c stb_image.h stb_image_resize.h stb_image_write.h
  group vsf/component/3rd-party/gato/raw/include
    ../../../../source/component/3rd-party/gato/raw/include/: color.h consolas-font.h image.h render.h surface.h svg.h
  group vsf/component/3rd-party/gato/raw/render
    ../../../../source/component/3rd-party/gato/raw/render/: render.c surface.c svg.c
  group vsf/component/3rd-party/gato/raw/scripts
    ../../../../source/component/3rd-party/gato/raw/scripts/: fixdep.c
  group vsf/component/3rd-party/lvgl/extension/lv_lib_freetype/raw
    ../../../../source/component/3rd-party/lvgl/extension/lv_lib_freetype/raw/: lv_freetype.c lv_freetype.h
  group vsf/component/3rd-party/lvgl/port
    ../../../../source/component/3rd-party/lvgl/port/: vsf_lvgl_port.c vsf_lvgl_port.h
  group vsf/component/3rd-party/lvgl/raw/lvgl
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/: lv_conf_template.h lvgl.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/: lv_conf_checker.h lv_version.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src/lv_core
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src/lv_draw
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw.h lv_draw_arc.h lv_draw_blend.h lv_draw_img.h lv_draw_label.h lv_draw_line.h lv_draw_mask.h lv_draw_rect.h lv_draw_triangle.h lv_img_buf.h lv_img_cache.h lv_img_decoder.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src/lv_font
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_font.h lv_font_fmt_txt.h lv_font_loader.h lv_symbol_def.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src/lv_hal
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src/lv_misc
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_types.h lv_utils.c lv_utils.h lv_debug.c lv_debug.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src/lv_widgets
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_chart.c lv_chart.h lv_checkbox.c lv_checkbox.h lv_cont.c lv_cont.h lv_cpicker.c lv_cpicker.h lv_dropdown.c lv_dropdown.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_keyboard.c lv_keyboard.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_linemeter.c lv_linemeter.h lv_list.c lv_list.h lv_msgbox.c lv_msgbox.h lv_objmask.c lv_objmask.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_spinner.c lv_spinner.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_textarea.c lv_textarea.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group vsf/component/3rd-party/lvgl/raw/lvgl/src/lv_themes
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_empty.c lv_theme_empty.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_template.c lv_theme_template.h
  group vsf/component/3rd-party/nnom/port
    ../../../../source/component/3rd-party/nnom/port/: nnom_port.h
  group vsf/component/3rd-party/nnom/raw/examples/auto_test
    ../../../../source/component/3rd-party/nnom/raw/examples/auto_test/: main.c
  group vsf/component/3rd-party/nnom/raw/examples/keyword_spotting/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/keyword_spotting/mcu/: main.c mfcc.c mfcc.h weights.h
  group vsf/component/3rd-party/nnom/raw/examples/mnist-cnn/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/mnist-cnn/mcu/: main_cnn.c weights_cnn.h
  group vsf/component/3rd-party/nnom/raw/examples/mnist-densenet/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/mnist-densenet/mcu/: main.c weights.h
  group vsf/component/3rd-party/nnom/raw/examples/mnist-simple/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/mnist-simple/mcu/: image.h main.c weights.h
  group vsf/component/3rd-party/nnom/raw/examples/octave-conv/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/octave-conv/mcu/: main.c weights.h
  group vsf/component/3rd-party/nnom/raw/examples/uci-inception/mcu
    ../../../../source/component/3rd-party/nnom/raw/examples/uci-inception/mcu/: main.c weights.h
  group vsf/component/3rd-party/nnom/raw/inc
    ../../../../source/component/3rd-party/nnom/raw/inc/: nnom.h nnom_activations.h nnom_layers.h nnom_local.h nnom_out_shape.h nnom_run.h nnom_utils.h
  group vsf/component/3rd-party/nnom/raw/port
    ../../../../source/component/3rd-party/nnom/raw/port/: nnom_port.h
  group vsf/component/3rd-party/nnom/raw/src
    ../../../../source/component/3rd-party/nnom/raw/src/: nnom.c nnom_activations.c nnom_layers.c nnom_local.c nnom_out_shape.c nnom_run.c nnom_utils.c
  group vsf/component/3rd-party/nuconsole/raw
    ../../../../source/component/3rd-party/nuconsole/raw/: NuConsole.c NuConsole.h NuConsole_Config.h
  group vsf/component/3rd-party/nuklear/raw
    ../../../../source/component/3rd-party/nuklear/raw/: nuklear.h
  group vsf/component/3rd-party/nuklear/raw/src
    ../../../../source/component/3rd-party/nuklear/raw/src/: nuklear.h nuklear_buffer.c nuklear_button.c nuklear_chart.c nuklear_color.c nuklear_color_picker.c nuklear_combo.c nuklear_context.c nuklear_contextual.c nuklear_draw.c nuklear_edit.c nuklear_font.c nuklear_group.c nuklear_image.c nuklear_input.c nuklear_internal.h nuklear_layout.c nuklear_list_view.c nuklear_math.c nuklear_menu.c nuklear_page_element.c nuklear_panel.c nuklear_pool.c nuklear_popup.c nuklear_progress.c nuklear_property.c nuklear_scrollbar.c nuklear_selectable.c nuklear_slider.c nuklear_string.c nuklear_style.c nuklear_table.c nuklear_text.c nuklear_text_editor.c nuklear_toggle.c nuklear_tooltip.c nuklear_tree.c nuklear_utf8.c nuklear_util.c nuklear_vertex.c nuklear_widget.c nuklear_window.c stb_rect_pack.h stb_truetype.h
  group vsf/component/3rd-party/segger_rtt/raw/RTT
    ../../../../source/component/3rd-party/segger_rtt/raw/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group vsf/component/3rd-party/vsfip/raw
    ../../../../source/component/3rd-party/vsfip/raw/: vsfip.c vsfip.h
  group vsf/component/3rd-party/vsfip/raw/netif
    ../../../../source/component/3rd-party/vsfip/raw/netif/: vsfip_netdrv_adapter.c vsfip_netdrv_adapter.h vsfip_netif.c vsfip_netif.h
  group vsf/component/3rd-party/vsfip/raw/netif/eth
    ../../../../source/component/3rd-party/vsfip/raw/netif/eth/: vsfip_eth.c vsfip_eth.h
  group vsf/component/3rd-party/vsfip/raw/proto/dhcp
    ../../../../source/component/3rd-party/vsfip/raw/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcp_common.h vsfip_dhcpc.c vsfip_dhcpc.h vsfip_dhcpd.c vsfip_dhcpd.h
  group vsf/component/3rd-party/vsfip/raw/proto/dns
    ../../../../source/component/3rd-party/vsfip/raw/proto/dns/: vsfip_dnsc.c vsfip_dnsc.h
  group vsf/component/3rd-party/vsfvm/extension/vsf/kernel
    ../../../../source/component/3rd-party/vsfvm/extension/vsf/kernel/: vsfvm_ext_kernel.c vsfvm_ext_kernel.h
  group vsf/component/3rd-party/vsfvm/extension/vsf/libusb
    ../../../../source/component/3rd-party/vsfvm/extension/vsf/libusb/: vsfvm_ext_libusb.c vsfvm_ext_libusb.h
  group vsf/component/3rd-party/vsfvm/raw
    ../../../../source/component/3rd-party/vsfvm/raw/: vsf_vm.h vsf_vm_cfg.h
  group vsf/component/3rd-party/vsfvm/raw/common
    ../../../../source/component/3rd-party/vsfvm/raw/common/: vsfvm_bytecode.h vsfvm_common.h vsfvm_objdump.c vsfvm_objdump.h
  group vsf/component/3rd-party/vsfvm/raw/compiler
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/: vsfvm_compiler.c vsfvm_compiler.h vsfvm_snapshot.c vsfvm_snapshot.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/lexer/: vsfvm_lexer.c vsfvm_lexer.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer/dart
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/lexer/dart/: vsfvm_lexer_dart.c vsfvm_lexer_dart.h
  group vsf/component/3rd-party/vsfvm/raw/extension
    ../../../../source/component/3rd-party/vsfvm/raw/extension/: vsfvm_ext.c
  group vsf/component/3rd-party/vsfvm/raw/extension/std
    ../../../../source/component/3rd-party/vsfvm/raw/extension/std/: vsfvm_ext_std.c vsfvm_ext_std.h
  group vsf/component/3rd-party/vsfvm/raw/runtime
    ../../../../source/component/3rd-party/vsfvm/raw/runtime/: vsfvm_runtime.c vsfvm_runtime.h
  group vsf/component/av
    ../../../../source/component/av/: vsf_av.h vsf_av_cfg.h
  group vsf/component/av/audio/decoder/wav
    ../../../../source/component/av/audio/decoder/wav/: vsf_wav.c vsf_wav.h
  group vsf/component/av/audio/driver/winsound
    ../../../../source/component/av/audio/driver/winsound/: vsf_winsound.c vsf_winsound.h
  group vsf/component/crypto
    ../../../../source/component/crypto/: vsf_crypto.h vsf_crypto_cfg.h
  group vsf/component/crypto/hash
    ../../../../source/component/crypto/hash/: vsf_hash.h
  group vsf/component/crypto/hash/crc
    ../../../../source/component/crypto/hash/crc/: vsf_crc.c vsf_crc.h
  group vsf/component/debugger
    ../../../../source/component/debugger/: vsf_debugger.h vsf_debugger_cfg.h
  group vsf/component/debugger/nulink
    ../../../../source/component/debugger/nulink/: NuConsole_stream.c NuConsole_stream.h
  group vsf/component/debugger/segger_rtt
    ../../../../source/component/debugger/segger_rtt/: segger_rtt_stream.c segger_rtt_stream.h
  group vsf/component/fs
    ../../../../source/component/fs/: vsf_fs.c vsf_fs.h vsf_fs_cfg.h
  group vsf/component/fs/driver/fatfs
    ../../../../source/component/fs/driver/fatfs/: vsf_fatfs.c vsf_fatfs.h
  group vsf/component/fs/driver/malfs
    ../../../../source/component/fs/driver/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/fs/driver/memfs
    ../../../../source/component/fs/driver/memfs/: vsf_memfs.c vsf_memfs.h
  group vsf/component/fs/driver/winfs
    ../../../../source/component/fs/driver/winfs/: vsf_winfs.c vsf_winfs.h
  group vsf/component/input
    ../../../../source/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h vsf_input_get_type.h vsf_input_get_type_1bit.h vsf_input_get_type_4bit.h
  group vsf/component/input/driver/hid
    ../../../../source/component/input/driver/hid/: vsf_input_hid.c vsf_input_hid.h
  group vsf/component/input/protocol
    ../../../../source/component/input/protocol/: vsf_input_gamepad.h vsf_input_keyboard.h vsf_input_mouse.h vsf_input_sensor.h vsf_input_touchscreen.h
  group vsf/component/mal
    ../../../../source/component/mal/: vsf_mal.c vsf_mal.h vsf_mal_cfg.h
  group vsf/component/mal/driver/fakefat32_mal
    ../../../../source/component/mal/driver/fakefat32_mal/: vsf_fakefat32_mal.c vsf_fakefat32_mal.h
  group vsf/component/mal/driver/file_mal
    ../../../../source/component/mal/driver/file_mal/: vsf_file_mal.c vsf_file_mal.h
  group vsf/component/mal/driver/mem_mal
    ../../../../source/component/mal/driver/mem_mal/: vsf_mem_mal.c vsf_mem_mal.h
  group vsf/component/mal/driver/mim_mal
    ../../../../source/component/mal/driver/mim_mal/: vsf_mim_mal.c vsf_mim_mal.h
  group vsf/component/mal/driver/scsi_mal
    ../../../../source/component/mal/driver/scsi_mal/: vsf_scsi_mal.c vsf_scsi_mal.h
  group vsf/component/scsi
    ../../../../source/component/scsi/: vsf_scsi.c vsf_scsi.h vsf_scsi_cfg.h
  group vsf/component/scsi/driver/mal_scsi
    ../../../../source/component/scsi/driver/mal_scsi/: vsf_mal_scsi.c vsf_mal_scsi.h
  group vsf/component/scsi/driver/virtual_scsi
    ../../../../source/component/scsi/driver/virtual_scsi/: vsf_virtual_scsi.c vsf_virtual_scsi.h
  group vsf/component/tcpip
    ../../../../source/component/tcpip/: vsf_tcpip.h vsf_tcpip_cfg.h
  group vsf/component/tcpip/netdrv
    ../../../../source/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group vsf/component/tcpip/netdrv/driver/wpcap
    ../../../../source/component/tcpip/netdrv/driver/wpcap/: vsf_netdrv_wpcap.c vsf_netdrv_wpcap.h
  group vsf/component/tcpip/socket
    ../../../../source/component/tcpip/socket/: vsf_socket.c vsf_socket.h
  group vsf/component/tcpip/socket/driver/lwip
    ../../../../source/component/tcpip/socket/driver/lwip/: vsf_socket_lwip.c vsf_socket_lwip.h
  group vsf/component/tcpip/socket/driver/win
    ../../../../source/component/tcpip/socket/driver/win/: vsf_socket_win.c vsf_socket_win.h
  group vsf/component/ui
    ../../../../source/component/ui/: vsf_ui.h vsf_ui_cfg.h
  group vsf/component/ui/disp
    ../../../../source/component/ui/disp/: vsf_disp.c vsf_disp.h
  group vsf/component/ui/disp/driver/fb
    ../../../../source/component/ui/disp/driver/fb/: vsf_disp_fb.c vsf_disp_fb.h
  group vsf/component/ui/disp/driver/sdl2
    ../../../../source/component/ui/disp/driver/sdl2/: vsf_disp_sdl2.c vsf_disp_sdl2.h
  group vsf/component/ui/disp/driver/sitronix/common
    ../../../../source/component/ui/disp/driver/sitronix/common/: vsf_disp_sitronix_common.c vsf_disp_sitronix_common.h
  group vsf/component/ui/disp/driver/sitronix/st7735
    ../../../../source/component/ui/disp/driver/sitronix/st7735/: vsf_disp_st7735.c vsf_disp_st7735.h
  group vsf/component/ui/disp/driver/sitronix/st7789
    ../../../../source/component/ui/disp/driver/sitronix/st7789/: vsf_disp_st7789.c vsf_disp_st7789.h
  group vsf/component/ui/disp/driver/solomon-systech/common
    ../../../../source/component/ui/disp/driver/solomon-systech/common/: vsf_disp_solomon_systech_common.c vsf_disp_solomon_systech_common.h
  group vsf/component/ui/disp/driver/solomon-systech/ssd1306
    ../../../../source/component/ui/disp/driver/solomon-systech/ssd1306/: vsf_disp_ssd1306.c vsf_disp_ssd1306.h
  group vsf/component/ui/disp/driver/usbd_uvc
    ../../../../source/component/ui/disp/driver/usbd_uvc/: vsf_disp_usbd_uvc.c vsf_disp_usbd_uvc.h
  group vsf/component/ui/disp/driver/vga/m480
    ../../../../source/component/ui/disp/driver/vga/m480/: vsf_disp_vga_m480.c vsf_disp_vga_m480.h
  group vsf/component/ui/tgui
    ../../../../source/component/ui/tgui/: vsf_tgui.c vsf_tgui.h vsf_tgui_cfg.h vsf_tgui_common.c vsf_tgui_common.h vsf_tgui_input.c
  group vsf/component/ui/tgui/controls
    ../../../../source/component/ui/tgui/controls/: __vk_tgui_slider.c __vk_tgui_slider.h __vsf_tgui_controls_common.h vsf_msg_tree_cfg.h vsf_tgui_button.c vsf_tgui_button.h vsf_tgui_control.c vsf_tgui_control.h vsf_tgui_controls.h vsf_tgui_controls_common.c vsf_tgui_label.c vsf_tgui_label.h vsf_tgui_list.c vsf_tgui_list.h vsf_tgui_panel.c vsf_tgui_panel.h vsf_tgui_text_list.c vsf_tgui_text_list.h
  group vsf/component/ui/tgui/utilities
    ../../../../source/component/ui/tgui/utilities/: vsf_tgui_text.c vsf_tgui_text.h
  group vsf/component/ui/tgui/view
    ../../../../source/component/ui/tgui/view/: vsf_tgui_v.c vsf_tgui_v.h
  group vsf/component/ui/tgui/view/simple_view
    ../../../../source/component/ui/tgui/view/simple_view/: vsf_tgui_sv_button.c vsf_tgui_sv_button.h vsf_tgui_sv_color.c vsf_tgui_sv_color.h vsf_tgui_sv_container.c vsf_tgui_sv_container.h vsf_tgui_sv_control.c vsf_tgui_sv_control.h vsf_tgui_sv_draw.c vsf_tgui_sv_draw.h vsf_tgui_sv_font.c vsf_tgui_sv_font.h vsf_tgui_sv_label.c vsf_tgui_sv_label.h vsf_tgui_sv_list.c vsf_tgui_sv_list.h vsf_tgui_sv_panel.c vsf_tgui_sv_panel.h vsf_tgui_sv_port.h vsf_tgui_sv_style.c vsf_tgui_sv_style.h vsf_tgui_sv_text_list.c vsf_tgui_sv_text_list.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group vsf/component/ui/tgui/view/template
    ../../../../source/component/ui/tgui/view/template/: vsf_tgui_v_button.c vsf_tgui_v_button.h vsf_tgui_v_container.c vsf_tgui_v_container.h vsf_tgui_v_control.c vsf_tgui_v_control.h vsf_tgui_v_label.c vsf_tgui_v_label.h vsf_tgui_v_panel.c vsf_tgui_v_panel.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group vsf/component/usb
    ../../../../source/component/usb/: vsf_usb.h vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../../../source/component/usb/common/: usb_common.h usb_desc.h
  group vsf/component/usb/common/class/CDC
    ../../../../source/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group vsf/component/usb/common/class/DFU
    ../../../../source/component/usb/common/class/DFU/: vsf_usb_dfu.h
  group vsf/component/usb/common/class/HID
    ../../../../source/component/usb/common/class/HID/: vsf_usb_ds4.h vsf_usb_HID.h vsf_usb_nspro.h vsf_usb_xb360.h
  group vsf/component/usb/common/class/HUB
    ../../../../source/component/usb/common/class/HUB/: vsf_usb_HUB.h
  group vsf/component/usb/common/class/MSC
    ../../../../source/component/usb/common/class/MSC/: vsf_usb_MSC.h
  group vsf/component/usb/common/class/UAC
    ../../../../source/component/usb/common/class/UAC/: vsf_usb_UAC.h
  group vsf/component/usb/common/class/XB1
    ../../../../source/component/usb/common/class/XB1/: vsf_usb_xb1.h
  group vsf/component/usb/device
    ../../../../source/component/usb/device/: vsf_usbd.c vsf_usbd.h vsf_usbd_drv_ifs.h
  group vsf/component/usb/device/class/CDC
    ../../../../source/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h vsf_usbd_CDCACM_desc.h
  group vsf/component/usb/device/class/HID
    ../../../../source/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h
  group vsf/component/usb/device/class/MSC
    ../../../../source/component/usb/device/class/MSC/: vsf_usbd_MSC.c vsf_usbd_MSC.h vsf_usbd_MSC_desc.h
  group vsf/component/usb/device/class/UAC
    ../../../../source/component/usb/device/class/UAC/: vsf_usbd_UAC.c vsf_usbd_UAC.h
  group vsf/component/usb/device/extension/bos
    ../../../../source/component/usb/device/extension/bos/: vsf_usbd_bos.h
  group vsf/component/usb/device/extension/webusb
    ../../../../source/component/usb/device/extension/webusb/: vsf_usbd_webusb.h
  group vsf/component/usb/device/extension/winusb
    ../../../../source/component/usb/device/extension/winusb/: vsf_usbd_winusb.h
  group vsf/component/usb/driver/dcd/usbip_dcd
    ../../../../source/component/usb/driver/dcd/usbip_dcd/: vsf_usbip_dcd.c vsf_usbip_dcd.h
  group vsf/component/usb/driver/hcd/libusb_hcd
    ../../../../source/component/usb/driver/hcd/libusb_hcd/: vsf_libusb_hcd.c vsf_libusb_hcd.h
  group vsf/component/usb/driver/hcd/ohci
    ../../../../source/component/usb/driver/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group vsf/component/usb/driver/hcd/winusb_hcd
    ../../../../source/component/usb/driver/hcd/winusb_hcd/: vsf_winusb_hcd.c vsf_winusb_hcd.h
  group vsf/component/usb/driver/otg/dwcotg
    ../../../../source/component/usb/driver/otg/dwcotg/: dwcotg_regs.h vsf_dwcotg_common.c vsf_dwcotg_common.h vsf_dwcotg_dcd.c vsf_dwcotg_dcd.h vsf_dwcotg_hcd.c vsf_dwcotg_hcd.h vsf_dwcotg_hw.h
  group vsf/component/usb/host
    ../../../../source/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group vsf/component/usb/host/class/BTHCI
    ../../../../source/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group vsf/component/usb/host/class/CDC
    ../../../../source/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group vsf/component/usb/host/class/DFU
    ../../../../source/component/usb/host/class/DFU/: vsf_usbh_dfu.c vsf_usbh_dfu.h
  group vsf/component/usb/host/class/HID
    ../../../../source/component/usb/host/class/HID/: vsf_usbh_ds4.c vsf_usbh_ds4.h vsf_usbh_HID.c vsf_usbh_HID.h vsf_usbh_nspro.c vsf_usbh_nspro.h vsf_usbh_xb360.c vsf_usbh_xb360.h
  group vsf/component/usb/host/class/HUB
    ../../../../source/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group vsf/component/usb/host/class/MSC
    ../../../../source/component/usb/host/class/MSC/: vsf_usbh_msc.c vsf_usbh_msc.h
  group vsf/component/usb/host/class/UAC
    ../../../../source/component/usb/host/class/UAC/: vsf_usbh_uac.c vsf_usbh_uac.h
  group vsf/component/usb/host/class/XB1
    ../../../../source/component/usb/host/class/XB1/: vsf_usbh_xb1.c vsf_usbh_xb1.h
  group vsf/component/usb/host/class/libusb
    ../../../../source/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group vsf/component/usb/host/class/rtl8152
    ../../../../source/component/usb/host/class/rtl8152/: vsf_usbh_rtl8152.c vsf_usbh_rtl8152.h
  group vsf/hal
    ../../../../source/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../../source/hal/arch/: __vsf_arch_interface.h vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/arm/cortex-m
    ../../../../source/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../../../source/hal/arch/arm/cortex-m/systick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../../../source/hal/driver/: driver.h
  group vsf/hal/driver/common
    ../../../../source/hal/driver/common/: common.h vsf_drv_usart_poll_util.h vsf_swi_template.h
  group vsf/hal/driver/common/usart
    ../../../../source/hal/driver/common/usart/: __usart_common.h
  group vsf/hal/driver/arm
    ../../../../source/hal/driver/arm/: driver.h
  group vsf/hal/driver/arm/mps2
    ../../../../source/hal/driver/arm/mps2/: __device.h driver.h
  group vsf/hal/driver/arm/mps2/common
    ../../../../source/hal/driver/arm/mps2/common/: __common.c __common.h
  group vsf/hal/driver/arm/mps2/CMSDK_CM7
    ../../../../source/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/interface
    ../../../../source/hal/interface/: vsf_interface_common.h vsf_interface_io.h vsf_interface_pm.h vsf_interface_spi.h vsf_interface_usart.h vsf_interface_usb.h
  group vsf/kernel
    ../../../../source/kernel/: vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/__eda
    ../../../../source/kernel/__eda/: vsf_eda_bmpevt.c vsf_eda_queue.c vsf_eda_sync.c vsf_eda_timer.c
  group vsf/kernel/shell
    ../../../../source/kernel/shell/: vsf_shell.c vsf_shell.h
  group vsf/kernel/shell/simple
    ../../../../source/kernel/shell/simple/: vsf_simple.h vsf_simple_bmpevt.c vsf_simple_bmpevt.h vsf_simple_task.c
  group vsf/kernel/task
    ../../../../source/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/osa_hal
    ../../../../source/osa_hal/: vsf_osa_hal.c vsf_osa_hal.h vsf_osa_hal_cfg.h
  group vsf/osa_hal/driver
    ../../../../source/osa_hal/driver/: driver.h
  group vsf/osa_hal/driver/customised
    ../../../../source/osa_hal/driver/customised/: driver.h
  group vsf/osa_hal/driver/customised/multiplex_hal
    ../../../../source/osa_hal/driver/customised/multiplex_hal/: driver.h vsf_multiplex_hal_common.h
  group vsf/osa_hal/driver/customised/multiplex_hal/iic
    ../../../../source/osa_hal/driver/customised/multiplex_hal/iic/: vsf_multiplex_iic.c vsf_multiplex_iic.h
  group vsf/osa_hal/driver/customised/multiplex_hal/spi
    ../../../../source/osa_hal/driver/customised/multiplex_hal/spi/: vsf_multiplex_spi.c vsf_multiplex_spi.h
  group vsf/osa_hal/sw_peripheral
    ../../../../source/osa_hal/sw_peripheral/: sw_periperhal_cfg.h sw_peripheral.h
  group vsf/osa_service
    ../../../../source/osa_service/: vsf_osa_service.c vsf_osa_service.h vsf_osa_service_cfg.h
  group vsf/osa_service/msg_tree
    ../../../../source/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group vsf/service
    ../../../../source/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/dynarr
    ../../../../source/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dynstack
    ../../../../source/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/fifo
    ../../../../source/service/fifo/: vsf_fifo.c vsf_fifo.h
  group vsf/service/heap
    ../../../../source/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/json
    ../../../../source/service/json/: vsf_json.c vsf_json.h
  group vsf/service/pbuf
    ../../../../source/service/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group vsf/service/pool
    ../../../../source/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/simple_stream
    ../../../../source/service/simple_stream/: vsf_simple_stream.c vsf_simple_stream.h
  group vsf/service/simple_stream/block_stream
    ../../../../source/service/simple_stream/block_stream/: vsf_block_stream.c vsf_block_stream.h
  group vsf/service/simple_stream/fifo_stream
    ../../../../source/service/simple_stream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/service/simple_stream/mem_stream
    ../../../../source/service/simple_stream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group vsf/service/stream
    ../../../../source/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/trace
    ../../../../source/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/shell/media/sdl2
    ../../../../source/shell/media/sdl2/: vsf_sdl2.c vsf_sdl2_cfg.h
  group vsf/shell/sys/linux
    ../../../../source/shell/sys/linux/: vsf_linux.c vsf_linux.h vsf_linux_cfg.h vsf_linux_socket.c
  group vsf/shell/sys/linux/include
    ../../../../source/shell/sys/linux/include/: dirent.h errno.h fcntl.h libusb.h poll.h pthread.h semaphore.h signal.h termios.h unistd.h
  group vsf/shell/sys/linux/include/linux
    ../../../../source/shell/sys/linux/include/linux/: limits.h
  group vsf/shell/sys/linux/include/sys
    ../../../../source/shell/sys/linux/include/sys/: mount.h select.h stat.h time.h types.h wait.h
  group vsf/shell/sys/linux/include/simple_libc
    ../../../../source/shell/sys/linux/include/simple_libc/: ctype.h stddef.h stdio.h stdlib.h string.h time.h wchar.h
  group vsf/shell/sys/linux/lib/glibc
    ../../../../source/shell/sys/linux/lib/glibc/: vsf_linux_glibc.c vsf_linux_glibc_ctype.c vsf_linux_glibc_pthread.c vsf_linux_glibc_sem.c vsf_linux_glibc_stdio.c vsf_linux_glibc_stdlib.c vsf_linux_glibc_string.c vsf_linux_glibc_time.c
  group vsf/shell/sys/linux/lib/libusb
    ../../../../source/shell/sys/linux/lib/libusb/: vsf_linux_libusb.c
  group vsf/shell/sys/linux/port/busybox
    ../../../../source/shell/sys/linux/port/busybox/: busybox.c busybox.h config.h
  group vsf/shell/sys/linux/port/busybox/shell
    ../../../../source/shell/sys/linux/port/busybox/shell/: vsh.c
  group vsf/shell/sys/xboot
    ../../../../source/shell/sys/xboot/include/: io.h stddef.h types.h xboot.h
    ../../../../source/shell/sys/xboot/: vsf_xboot.c vsf_xboot_cfg.h
  group vsf/utilities
    ../../../../source/utilities/: communicate.h ooc_class.h vsf_utilities.h vsf_utilities_cfg.h
  group vsf/utilities/3rd-party/PLOOC
    ../../../../source/utilities/3rd-party/PLOOC/raw/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_simple_c90.h plooc_class_strict.h
  group vsf/utilities/compiler
    ../../../../source/utilities/compiler/: compiler.h
  group vsf/utilities/compiler/__common
    ../../../../source/utilities/compiler/__common/: __compiler.h __retarget_io.c __type.h
  group vsf/utilities/compiler/arm
    ../../../../source/utilities/compiler/arm/: arm_compiler.h retarget_io.c type.h
  group vsf/utilities/language_extension
    ../../../../source/utilities/language_extension/: code_region.c code_region.h delegate.c delegate.h language_extension.h simple_sprintf.c simple_sscanf.c
  group vsf/utilities/preprocessor
    ../../../../source/utilities/preprocessor/: mf_u8_dec2str.h vsf_connect.h vsf_repeat_macro.h
  group vsf/utilities/template
    ../../../../source/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h vsf_queue.c vsf_queue.h
