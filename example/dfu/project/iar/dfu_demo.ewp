# IAR project dfu_demo.ewp, settings and files
configuration dfu_demo (ARM, debug)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __VSF__; __Nuvoton__; __M484__
  ICCARM.CCIncludePath2: ..\..; ..\..\..\template\demo\common; ..\..\..\..\source; ..\..\..\..\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\Core\Include; ..\..\..\..\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\DSP\Include; ..\..\..\..\source\utilities\compiler\arm\3rd-party\CMSIS\CMSIS\NN\Include; ..\..\..\..\source\component\3rd-party\nuconsole\raw; ..\..\..\..\source\component\3rd-party\segger\port\Config; ..\..\..\..\source\component\3rd-party\segger\raw\RTT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dfu_demo.hex
  ILINK.IlinkOutputFile: dfu_demo.out
  ILINK.IlinkIcfFile: target\M484\m480.icf
  ILINK.IlinkExtraOptions: --no_entry
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group usrapp
    ../../: main.c vsf_dfu.c vsf_usr_cfg.h
  group usrapp/common
    ../../../template/demo/common/: usrapp_usbd_common.c usrapp_usbd_common.h
  group vsf
    ../../../../source/: vsf.h vsf_cfg.h
  group vsf/component
    ../../../../source/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/3rd-party/btstack/firmware/bcm/bcm20702
    ../../../../source/component/3rd-party/btstack/firmware/bcm/bcm20702/: bt_firmware_image.c
  group vsf/component/3rd-party/btstack/port
    ../../../../source/component/3rd-party/btstack/port/: btstack_run_loop_vsf.c btstack_run_loop_vsf.h hci_dump_vsf.c hci_transport_h2_vsf.c
  group vsf/component/3rd-party/btstack/raw/chipset/bcm
    ../../../../source/component/3rd-party/btstack/raw/chipset/bcm/: btstack_chipset_bcm.c btstack_chipset_bcm.h btstack_chipset_bcm_download_firmware.c btstack_chipset_bcm_download_firmware.h
  group vsf/component/3rd-party/btstack/raw/chipset/csr
    ../../../../source/component/3rd-party/btstack/raw/chipset/csr/: btstack_chipset_csr.c
  group vsf/component/3rd-party/btstack/raw/src
    ../../../../source/component/3rd-party/btstack/raw/src/: ad_parser.c btstack_linked_list.c btstack_memory.c btstack_memory_pool.c btstack_run_loop.c btstack_util.c hci.c hci_cmd.c l2cap.c l2cap_signaling.c
  group vsf/component/3rd-party/btstack/raw/src/classic
    ../../../../source/component/3rd-party/btstack/raw/src/classic/: hid_device.c rfcomm.c sdp_server.c sdp_util.c spp_server.c
  group vsf/component/3rd-party/littlevgl/6.0/port
    ../../../../source/component/3rd-party/lvgl/port/: vsf_lvgl_port.c vsf_lvgl_port.h
  group vsf/component/3rd-party/littlevgl/6.0/raw
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/: lvgl.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/: lv_conf_checker.h lv_version.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_core
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_draw
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_basic.c lv_draw_basic.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_font
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c lv_symbol_def.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_hal
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_misc
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_types.h lv_utils.c lv_utils.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_objx
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_objx/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_preload.c lv_preload.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_themes
    ../../../../source/component/3rd-party/lvgl/raw/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_nemo.c lv_theme_nemo.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h
  group vsf/component/3rd-party/lwip/1.4.1/port
    ../../../../source/component/3rd-party/lwip/port/: lwip_netdrv_adapter.c lwip_netdrv_adapter.h lwippools.h
  group vsf/component/3rd-party/lwip/1.4.1/port/arch
    ../../../../source/component/3rd-party/lwip/port/arch/: cc.h perf.h sys_arch.c sys_arch.h
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/api
    ../../../../source/component/3rd-party/lwip/raw/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core
    ../../../../source/component/3rd-party/lwip/raw/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv4
    ../../../../source/component/3rd-party/lwip/raw/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv6
    ../../../../source/component/3rd-party/lwip/raw/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/snmp
    ../../../../source/component/3rd-party/lwip/raw/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/netif
    ../../../../source/component/3rd-party/lwip/raw/src/netif/: etharp.c
  group vsf/component/3rd-party/nnom/port
    ../../../../source/component/3rd-party/nnom/port/: nnom_port.h
  group vsf/component/3rd-party/nnom/raw/inc
    ../../../../source/component/3rd-party/nnom/raw/inc/: nnom.h nnom_activations.h nnom_layers.h nnom_local.h nnom_out_shape.h nnom_run.h nnom_utils.h
  group vsf/component/3rd-party/nnom/raw/src
    ../../../../source/component/3rd-party/nnom/raw/src/: nnom.c nnom_activations.c nnom_layers.c nnom_local.c nnom_out_shape.c nnom_run.c nnom_utils.c
  group vsf/component/3rd-party/nuconsole/raw
    ../../../../source/component/3rd-party/nuconsole/raw/: NuConsole.c NuConsole.h NuConsole_Config.h
  group vsf/component/3rd-party/segger/raw/RTT
    ../../../../source/component/3rd-party/segger/raw/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group vsf/component/3rd-party/vsfvm/extension/vsf/kernel
    ../../../../source/component/3rd-party/vsfvm/extension/vsf/kernel/: vsfvm_ext_kernel.c vsfvm_ext_kernel.h
  group vsf/component/3rd-party/vsfvm/extension/vsf/libusb
    ../../../../source/component/3rd-party/vsfvm/extension/vsf/libusb/: vsfvm_ext_libusb.c vsfvm_ext_libusb.h
  group vsf/component/3rd-party/vsfvm/raw
    ../../../../source/component/3rd-party/vsfvm/raw/: vsf_vm.h vsf_vm_cfg.h
  group vsf/component/3rd-party/vsfvm/raw/common
    ../../../../source/component/3rd-party/vsfvm/raw/common/: vsfvm_bytecode.h vsfvm_common.h vsfvm_objdump.c vsfvm_objdump.h
  group vsf/component/3rd-party/vsfvm/raw/compiler
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/: vsfvm_compiler.c vsfvm_compiler.h vsfvm_snapshot.c vsfvm_snapshot.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/lexer/: vsfvm_lexer.c vsfvm_lexer.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer/dart
    ../../../../source/component/3rd-party/vsfvm/raw/compiler/lexer/dart/: vsfvm_lexer_dart.c vsfvm_lexer_dart.h
  group vsf/component/3rd-party/vsfvm/raw/extension
    ../../../../source/component/3rd-party/vsfvm/raw/extension/: vsfvm_ext.c
  group vsf/component/3rd-party/vsfvm/raw/extension/std
    ../../../../source/component/3rd-party/vsfvm/raw/extension/std/: vsfvm_ext_std.c vsfvm_ext_std.h
  group vsf/component/3rd-party/vsfvm/raw/runtime
    ../../../../source/component/3rd-party/vsfvm/raw/runtime/: vsfvm_runtime.c vsfvm_runtime.h
  group vsf/component/av
    ../../../../source/component/av/: vsf_av.h vsf_av_cfg.h
  group vsf/component/av/audio
    ../../../../source/component/av/audio/: vsf_audio.c vsf_audio.h
  group vsf/component/av/audio/decoder/wav
    ../../../../source/component/av/audio/decoder/wav/: vsf_wav.c vsf_wav.h
  group vsf/component/av/audio/driver/winsound
    ../../../../source/component/av/audio/driver/winsound/: vsf_winsound.c vsf_winsound.h
  group vsf/component/debugger
    ../../../../source/component/debugger/: vsf_debugger.h vsf_debugger_cfg.h
  group vsf/component/debugger/nulink
    ../../../../source/component/debugger/nulink/: NuConsole_stream.c NuConsole_stream.h
  group vsf/component/debugger/segger
    ../../../../source/component/debugger/segger/: segger_rtt_stream.c segger_rtt_stream.h
  group vsf/component/fs
    ../../../../source/component/fs/: vsf_fs.c vsf_fs.h vsf_fs_cfg.h
  group vsf/component/fs/driver/fatfs
    ../../../../source/component/fs/driver/fatfs/: vsf_fatfs.c vsf_fatfs.h
  group vsf/component/fs/driver/malfs
    ../../../../source/component/fs/driver/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/fs/driver/memfs
    ../../../../source/component/fs/driver/memfs/: vsf_memfs.c vsf_memfs.h
  group vsf/component/fs/driver/winfs
    ../../../../source/component/fs/driver/winfs/: vsf_winfs.c vsf_winfs.h
  group vsf/component/input
    ../../../../source/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h
  group vsf/component/input/driver/hid
    ../../../../source/component/input/driver/hid/: vsf_input_hid.c vsf_input_hid.h
  group vsf/component/input/driver/nspro
    ../../../../source/component/input/driver/nspro/: vsf_input_nspro.c vsf_input_nspro.h
  group vsf/component/input/protocol
    ../../../../source/component/input/protocol/: vsf_input_gamepad.h vsf_input_keyboard.h vsf_input_mouse.h vsf_input_sensor.h vsf_input_touchscreen.h
  group vsf/component/mal
    ../../../../source/component/mal/: vsf_mal.c vsf_mal.h vsf_mal_cfg.h
  group vsf/component/mal/driver/fakefat32_mal
    ../../../../source/component/mal/driver/fakefat32_mal/: vsf_fakefat32_mal.c vsf_fakefat32_mal.h
  group vsf/component/mal/driver/file_mal
    ../../../../source/component/mal/driver/file_mal/: vsf_file_mal.c vsf_file_mal.h
  group vsf/component/mal/driver/mem_mal
    ../../../../source/component/mal/driver/mem_mal/: vsf_mem_mal.c vsf_mem_mal.h
  group vsf/component/mal/driver/mim_mal
    ../../../../source/component/mal/driver/mim_mal/: vsf_mim_mal.c vsf_mim_mal.h
  group vsf/component/mal/driver/scsi_mal
    ../../../../source/component/mal/driver/scsi_mal/: vsf_scsi_mal.c vsf_scsi_mal.h
  group vsf/component/scsi
    ../../../../source/component/scsi/: vsf_scsi.c vsf_scsi.h vsf_scsi_cfg.h
  group vsf/component/scsi/driver/mal_scsi
    ../../../../source/component/scsi/driver/mal_scsi/: vsf_mal_scsi.c vsf_mal_scsi.h
  group vsf/component/scsi/driver/virtual_scsi
    ../../../../source/component/scsi/driver/virtual_scsi/: vsf_virtual_scsi.c vsf_virtual_scsi.h
  group vsf/component/tcpip
    ../../../../source/component/tcpip/: vsf_tcpip_cfg.h
  group vsf/component/tcpip/netdrv
    ../../../../source/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group vsf/component/ui
    ../../../../source/component/ui/: vsf_ui_cfg.h
  group vsf/component/ui/disp
    ../../../../source/component/ui/disp/: vsf_disp.c vsf_disp.h
  group vsf/component/ui/disp/driver/usbd_uvc
    ../../../../source/component/ui/disp/driver/usbd_uvc/: vsf_disp_usbd_uvc.c vsf_disp_usbd_uvc.h
  group vsf/component/usb
    ../../../../source/component/usb/: vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../../../source/component/usb/common/: usb_common.h usb_desc.h
  group vsf/component/usb/common/class/CDC
    ../../../../source/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group vsf/component/usb/common/class/HID
    ../../../../source/component/usb/common/class/HID/: vsf_usb_ds4.h vsf_usb_HID.h vsf_usb_nspro.h vsf_usb_xb360.h
  group vsf/component/usb/common/class/MSC
    ../../../../source/component/usb/common/class/MSC/: vsf_usb_MSC.h
  group vsf/component/usb/common/class/UVC
    ../../../../source/component/usb/common/class/UVC/: vsf_usb_UVC.h
  group vsf/component/usb/common/class/XB1
    ../../../../source/component/usb/common/class/XB1/: vsf_usb_xb1.h
  group vsf/component/usb/device
    ../../../../source/component/usb/device/: vsf_usbd.c vsf_usbd.h
  group vsf/component/usb/device/class/CDC
    ../../../../source/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h vsf_usbd_CDCACM_desc.h
  group vsf/component/usb/device/class/HID
    ../../../../source/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h
  group vsf/component/usb/device/class/MSC
    ../../../../source/component/usb/device/class/MSC/: vsf_usbd_MSC.c vsf_usbd_MSC.h vsf_usbd_MSC_desc.h
  group vsf/component/usb/device/class/UVC
    ../../../../source/component/usb/device/class/UVC/: vsf_usbd_UVC.c vsf_usbd_UVC.h
  group vsf/component/usb/driver/hcd/ohci
    ../../../../source/component/usb/driver/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group vsf/component/usb/driver/otg/dwcotg
    ../../../../source/component/usb/driver/otg/dwcotg/: dwcotg_regs.h vsf_dwcotg_common.c vsf_dwcotg_common.h vsf_dwcotg_dcd.c vsf_dwcotg_dcd.h
  group vsf/component/usb/driver/otg/musb/fdrc
    ../../../../source/component/usb/driver/otg/musb/fdrc/: __vsf_musb_fdrc_common.c __vsf_musb_fdrc_common.h vsf_musb_fdrc_dcd.c vsf_musb_fdrc_dcd.h
  group vsf/component/usb/host
    ../../../../source/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group vsf/component/usb/host/class/BTHCI
    ../../../../source/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group vsf/component/usb/host/class/CDC
    ../../../../source/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group vsf/component/usb/host/class/HID
    ../../../../source/component/usb/host/class/HID/: vsf_usbh_ds4.c vsf_usbh_ds4.h vsf_usbh_HID.c vsf_usbh_HID.h vsf_usbh_nspro.c vsf_usbh_nspro.h vsf_usbh_xb360.c vsf_usbh_xb360.h
  group vsf/component/usb/host/class/HUB
    ../../../../source/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group vsf/component/usb/host/class/libusb
    ../../../../source/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group vsf/component/usb/host/class/MSC
    ../../../../source/component/usb/host/class/MSC/: vsf_usbh_msc.c vsf_usbh_msc.h
  group vsf/component/usb/host/class/UAC
    ../../../../source/component/usb/host/class/UAC/: vsf_usbh_uac.c vsf_usbh_uac.h
  group vsf/component/usb/host/class/XB1
    ../../../../source/component/usb/host/class/XB1/: vsf_usbh_xb1.c vsf_usbh_xb1.h
  group vsf/hal
    ../../../../source/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../../source/hal/arch/: __vsf_arch_interface.h vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/arm/cortex-a
    ../../../../source/hal/arch/arm/cortex-a/: cortex_a_generic.c cortex_a_generic.h
  group vsf/hal/arch/arm/cortex-m
    ../../../../source/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../../../source/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../../../source/hal/driver/: driver.h
  group vsf/hal/driver/arm
    ../../../../source/hal/driver/arm/: driver.h
  group vsf/hal/driver/arm/mps2
    ../../../../source/hal/driver/arm/mps2/: __device.h driver.h
  group vsf/hal/driver/arm/mps2/CMSDK_CM0
    ../../../../source/hal/driver/arm/mps2/CMSDK_CM0/: device.h driver.c driver.h startup_ARMCM0.c
  group vsf/hal/driver/arm/mps2/CMSDK_CM7
    ../../../../source/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/driver/arm/mps2/common
    ../../../../source/hal/driver/arm/mps2/common/: __common.c __common.h
  group vsf/hal/driver/common
    ../../../../source/hal/driver/common/: common.h
  group vsf/hal/driver/Nuvoton
    ../../../../source/hal/driver/Nuvoton/: driver.h
  group vsf/hal/driver/Nuvoton/M480
    ../../../../source/hal/driver/Nuvoton/M480/: __device.h
  group vsf/hal/driver/Nuvoton/M480/common
    ../../../../source/hal/driver/Nuvoton/M480/common/: __common.c __common.h
  group vsf/hal/driver/Nuvoton/M480/common/dma
    ../../../../source/hal/driver/Nuvoton/M480/common/dma/: dma.c dma.h
  group vsf/hal/driver/Nuvoton/M480/common/io
    ../../../../source/hal/driver/Nuvoton/M480/common/io/: io.c io.h
  group vsf/hal/driver/Nuvoton/M480/common/pm
    ../../../../source/hal/driver/Nuvoton/M480/common/pm/: pm.c pm.h
  group vsf/hal/driver/Nuvoton/M480/common/spi
    ../../../../source/hal/driver/Nuvoton/M480/common/spi/: spi.c spi.h
  group vsf/hal/driver/Nuvoton/M480/common/usart
    ../../../../source/hal/driver/Nuvoton/M480/common/usart/: usart.c usart.h
  group vsf/hal/driver/Nuvoton/M480/common/usb
    ../../../../source/hal/driver/Nuvoton/M480/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb/dc
    ../../../../source/hal/driver/Nuvoton/M480/common/usb/dc/: usbd_hs.c usbd_hs.h
  group vsf/hal/driver/Nuvoton/M480/common/usb/ohci
    ../../../../source/hal/driver/Nuvoton/M480/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/Include
    ../../../../source/hal/driver/Nuvoton/M480/common/vendor/Include/: acmp_reg.h bpwm_reg.h can_reg.h clk_reg.h crc_reg.h crypto_reg.h dac_reg.h eadc_reg.h ebi_reg.h ecap_reg.h emac_reg.h epwm_reg.h fmc_reg.h gpio_reg.h hsotg_reg.h hsusbd_reg.h hsusbh_reg.h i2c_reg.h i2s_reg.h M480.h NuMicro.h opa_reg.h otg_reg.h pdma_reg.h qei_reg.h qspi_reg.h rtc_reg.h sc_reg.h sdh_reg.h spi_reg.h spim_reg.h sys_reg.h system_M480.h timer_reg.h uart_reg.h ui2c_reg.h usbd_reg.h usbh_reg.h uspi_reg.h uuart_reg.h wdt_reg.h wwdt_reg.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/startup
    ../../../../source/hal/driver/Nuvoton/M480/common/vendor/startup/IAR/: startup_M480.s.template
  group vsf/hal/driver/Nuvoton/M480/M484
    ../../../../source/hal/driver/Nuvoton/M480/M484/: device.h driver.c driver.h startup_M484.c
  group vsf/hal/driver/Nuvoton/NUC500
    ../../../../source/hal/driver/Nuvoton/NUC500/: __device.h
  group vsf/hal/driver/Nuvoton/NUC500/common/usb
    ../../../../source/hal/driver/Nuvoton/NUC500/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/NUC500/common/usb/ohci
    ../../../../source/hal/driver/Nuvoton/NUC500/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/NUC500/NUC505
    ../../../../source/hal/driver/Nuvoton/NUC500/NUC505/: device.h driver.c driver.h startup_NUC505.c
  group vsf/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include
    ../../../../source/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include/: NUC505Series.h
  group vsf/hal/driver/ST
    ../../../../source/hal/driver/ST/: driver.h
  group vsf/hal/driver/ST/STM32F730
    ../../../../source/hal/driver/ST/STM32F730/: __device.h
  group vsf/hal/driver/ST/STM32F730/common
    ../../../../source/hal/driver/ST/STM32F730/common/: __common.c __common.h
  group vsf/hal/driver/ST/STM32F730/common/vendor/Include
    ../../../../source/hal/driver/ST/STM32F730/common/vendor/Include/: stm32f730xx.h
  group vsf/hal/driver/ST/STM32F730/STM32F730R8
    ../../../../source/hal/driver/ST/STM32F730/STM32F730R8/: device.h driver.c driver.h startup_STM32F730R8.c
  group vsf/hal/driver/template
    ../../../../source/hal/driver/template/: driver.h
  group vsf/hal/driver/template/__series_name__/__device_name_1__
    ../../../../source/hal/driver/template/__series_name__/__device_name_1__/: driver.c driver.h
  group vsf/hal/driver/TI
    ../../../../source/hal/driver/TI/: driver.h
  group vsf/hal/driver/TI/AM335X/AM3352
    ../../../../source/hal/driver/TI/AM335X/AM3352/: device.h driver.c driver.h
  group vsf/hal/driver/WinnerMicro
    ../../../../source/hal/driver/WinnerMicro/: driver.h
  group vsf/hal/driver/WinnerMicro/W60X
    ../../../../source/hal/driver/WinnerMicro/W60X/: device.h
  group vsf/hal/driver/WinnerMicro/W60X/common
    ../../../../source/hal/driver/WinnerMicro/W60X/common/: common.c common.h
  group vsf/hal/driver/WinnerMicro/W60X/common/io
    ../../../../source/hal/driver/WinnerMicro/W60X/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/usart
    ../../../../source/hal/driver/WinnerMicro/W60X/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include
    ../../../../source/hal/driver/WinnerMicro/W60X/common/vendor/Include/: wm_regs.h
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup
    ../../../../source/hal/driver/WinnerMicro/W60X/common/vendor/startup/IAR/: startup_venus.s
  group vsf/hal/driver/WinnerMicro/W60X/W600
    ../../../../source/hal/driver/WinnerMicro/W60X/W600/: device.h driver.c driver.h
  group vsf/kernel
    ../../../../source/kernel/: vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/__eda
    ../../../../source/kernel/__eda/: vsf_eda_bmpevt.c vsf_eda_queue.c vsf_eda_sync.c vsf_eda_timer.c
  group vsf/kernel/shell
    ../../../../source/kernel/shell/: vsf_shell.c
  group vsf/kernel/shell/simple
    ../../../../source/kernel/shell/simple/: vsf_simple.h vsf_simple_bmpevt.c vsf_simple_bmpevt.h vsf_simple_task.c
  group vsf/kernel/task
    ../../../../source/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.c vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/osa_service
    ../../../../source/osa_service/: vsf_osa_service.c vsf_osa_service.h vsf_osa_service_cfg.h
  group vsf/osa_service/msg_tree
    ../../../../source/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group vsf/service
    ../../../../source/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/dynarr
    ../../../../source/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dynstack
    ../../../../source/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/fifo
    ../../../../source/service/fifo/: vsf_fifo.c vsf_fifo.h
  group vsf/service/heap
    ../../../../source/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/json
    ../../../../source/service/json/: vsf_json.c vsf_json.h
  group vsf/service/pbuf
    ../../../../source/service/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group vsf/service/pool
    ../../../../source/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/simple_stream
    ../../../../source/service/simple_stream/: vsf_simple_stream.c vsf_simple_stream.h
  group vsf/service/simple_stream/block_stream
    ../../../../source/service/simple_stream/block_stream/: vsf_block_stream.c vsf_block_stream.h
  group vsf/service/simple_stream/fifo_stream
    ../../../../source/service/simple_stream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/service/simple_stream/mem_stream
    ../../../../source/service/simple_stream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group vsf/service/stream
    ../../../../source/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/stream/pbuf_queue
    ../../../../source/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group vsf/service/trace
    ../../../../source/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/shell/sys/linux
    ../../../../source/shell/sys/linux/: vsf_linux.c vsf_linux.h vsf_linux_cfg.h
  group vsf/shell/sys/linux/include
    ../../../../source/shell/sys/linux/include/: dirent.h fcntl.h libusb.h poll.h pthread.h semaphore.h signal.h stdio.h termios.h time.h unistd.h
  group vsf/shell/sys/linux/include/linux
    ../../../../source/shell/sys/linux/include/linux/: limits.h
  group vsf/shell/sys/linux/include/sys
    ../../../../source/shell/sys/linux/include/sys/: mount.h stat.h time.h types.h wait.h
  group vsf/shell/sys/linux/kernel/fs
    ../../../../source/shell/sys/linux/kernel/fs/: vsf_linux_fs.c vsf_linux_fs.h
  group vsf/shell/sys/linux/kernel/fs/vfs
    ../../../../source/shell/sys/linux/kernel/fs/vfs/: vsf_linux_vfs.c vsf_linux_vfs.h
  group vsf/shell/sys/linux/kernel/fs/vfs/devfs
    ../../../../source/shell/sys/linux/kernel/fs/vfs/devfs/: vsf_linux_devfs.c vsf_linux_devfs.h
  group vsf/shell/sys/linux/kernel/socket
    ../../../../source/shell/sys/linux/kernel/socket/: vsf_linux_socket.c vsf_linux_socket.h
  group vsf/shell/sys/linux/kernel/socket/inet
    ../../../../source/shell/sys/linux/kernel/socket/inet/: vsf_linux_socket_inet_lwip.c
  group vsf/shell/sys/linux/kernel/socket/unix
    ../../../../source/shell/sys/linux/kernel/socket/unix/: vsf_linux_socket_unix.c
  group vsf/shell/sys/linux/lib/glibc
    ../../../../source/shell/sys/linux/lib/glibc/: vsf_linux_glibc.c vsf_linux_glibc_pthread.c vsf_linux_glibc_sem.c vsf_linux_glibc_stdio.c vsf_linux_glibc_stdlib.c vsf_linux_glibc_string.c vsf_linux_glibc_time.c
  group vsf/shell/sys/linux/lib/libusb
    ../../../../source/shell/sys/linux/lib/libusb/: vsf_linux_libusb.c
  group vsf/shell/sys/linux/port/busybox
    ../../../../source/shell/sys/linux/port/busybox/: busybox.c busybox.h config.h
  group vsf/shell/sys/linux/port/busybox/shell
    ../../../../source/shell/sys/linux/port/busybox/shell/: vsh.c
  group vsf/utilities
    ../../../../source/utilities/: communicate.h compiler.h ooc_class.h
  group vsf/utilities/3rd-party/PLOOC/raw
    ../../../../source/utilities/3rd-party/PLOOC/raw/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_simple_c90.h plooc_class_strict.h
  group vsf/utilities/compiler
    ../../../../source/utilities/compiler/arm/: arm_compiler.h retarget_io.c type.h
  group vsf/utilities/compiler/__common
    ../../../../source/utilities/compiler/__common/: __compiler.h __signal.h __type.h
  group vsf/utilities/language_extension
    ../../../../source/utilities/language_extension/: code_region.c code_region.h delegate.c language_extension.h simple_sprintf.c
  group vsf/utilities/preprocessor
    ../../../../source/utilities/preprocessor/: mf_u8_dec2str.h mrepeat.h preprocessor.h tpaste.h
  group vsf/utilities/template
    ../../../../source/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h vsf_queue.c vsf_queue.h
