# IAR project spl.ewp, settings and files
configuration spl (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: __CPU_ARM9__; __Allwinner__; __F1C100S__
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\vsf; ..\..\..\..\vsf\utilities\compiler\arm\CMSIS\Core_Legacy\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spl.bin
  postbuild: target\f1c100s\binary\post-build.bat $EXE_DIR$\spl.bin
  ILINK.IlinkOutputFile: spl.out
  ILINK.IlinkIcfFile: target\f1c100s\f1c100s_spl.icf
  ILINK.IlinkExtraOptions: --no_entry
  ILINK.IlinkProgramEntryLabel: _entry
  group (top)
    ../../../../vsf/kernel/lib/: vsf_kernel_armv6m_full_size.a vsf_kernel_armv7m_full_size.a
    kernel_lib/: vsf_kernel_armv7em_full_size.a
  group usrapp
    ../../: vsf_usr_cfg.h
  group vsf
    ../../../../vsf/: vsf.h vsf_cfg.h
  group vsf/hal
    ../../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../../vsf/hal/arch/: __vsf_arch_interface.h vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/arm/arm9
    ../../../../vsf/hal/arch/arm/arm9/: arm9_generic.c arm9_generic.h
  group vsf/hal/arch/arm/cortex-a
    ../../../../vsf/hal/arch/arm/cortex-a/: cortex_a_generic.c cortex_a_generic.h
  group vsf/hal/arch/arm/cortex-m
    ../../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../../../vsf/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../../../vsf/hal/driver/: driver.h
  group vsf/hal/driver/Allwinner
    ../../../../vsf/hal/driver/Allwinner/: driver.h
  group vsf/hal/driver/Allwinner/F1CX00S
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/: __device.h
  group vsf/hal/driver/Allwinner/F1CX00S/common
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/: __common.c __common.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/dram
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/dram/: dram.c dram.h
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/F1C100S/: device.h driver.c driver.h f1c100s_reg.h
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup/spl
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup/spl/: spl_c.c
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup/spl/asm
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup/spl/asm/iar/: spl_entry.S
  group vsf/hal/driver/arm
    ../../../../vsf/hal/driver/arm/: driver.h
  group vsf/hal/driver/arm/mps2
    ../../../../vsf/hal/driver/arm/mps2/: __device.h driver.h
  group vsf/hal/driver/arm/mps2/CMSDK_CM0
    ../../../../vsf/hal/driver/arm/mps2/CMSDK_CM0/: device.h driver.c driver.h startup_ARMCM0.c
  group vsf/hal/driver/arm/mps2/CMSDK_CM7
    ../../../../vsf/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/driver/arm/mps2/common
    ../../../../vsf/hal/driver/arm/mps2/common/: __common.c __common.h
  group vsf/hal/driver/common
    ../../../../vsf/hal/driver/common/: common.h
  group vsf/hal/driver/Nuvoton
    ../../../../vsf/hal/driver/Nuvoton/: driver.h
  group vsf/hal/driver/Nuvoton/M480
    ../../../../vsf/hal/driver/Nuvoton/M480/: __device.h
  group vsf/hal/driver/Nuvoton/M480/common
    ../../../../vsf/hal/driver/Nuvoton/M480/common/: __common.c __common.h
  group vsf/hal/driver/Nuvoton/M480/common/io
    ../../../../vsf/hal/driver/Nuvoton/M480/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/pm
    ../../../../vsf/hal/driver/Nuvoton/M480/common/pm/: pm.c pm.h pm_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usart
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb/dc
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usb/dc/: usbd_hs.c usbd_hs.h
  group vsf/hal/driver/Nuvoton/M480/common/usb/ohci
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/Include
    ../../../../vsf/hal/driver/Nuvoton/M480/common/vendor/Include/: acmp_reg.h bpwm_reg.h can_reg.h clk_reg.h crc_reg.h crypto_reg.h dac_reg.h eadc_reg.h ebi_reg.h ecap_reg.h emac_reg.h epwm_reg.h fmc_reg.h gpio_reg.h hsotg_reg.h hsusbd_reg.h hsusbh_reg.h i2c_reg.h i2s_reg.h M480.h NuMicro.h opa_reg.h otg_reg.h pdma_reg.h qei_reg.h qspi_reg.h rtc_reg.h sc_reg.h sdh_reg.h spi_reg.h spim_reg.h sys_reg.h system_M480.h timer_reg.h uart_reg.h ui2c_reg.h usbd_reg.h usbh_reg.h uspi_reg.h uuart_reg.h wdt_reg.h wwdt_reg.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/startup
    ../../../../vsf/hal/driver/Nuvoton/M480/common/vendor/startup/IAR/: startup_M480.s.template
  group vsf/hal/driver/Nuvoton/M480/M484
    ../../../../vsf/hal/driver/Nuvoton/M480/M484/: device.h driver.c driver.h startup_M484.c
  group vsf/hal/driver/Nuvoton/NUC500
    ../../../../vsf/hal/driver/Nuvoton/NUC500/: __device.h
  group vsf/hal/driver/Nuvoton/NUC500/common/usb
    ../../../../vsf/hal/driver/Nuvoton/NUC500/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/NUC500/common/usb/ohci
    ../../../../vsf/hal/driver/Nuvoton/NUC500/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/NUC500/NUC505
    ../../../../vsf/hal/driver/Nuvoton/NUC500/NUC505/: device.h driver.c driver.h startup_NUC505.c
  group vsf/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include
    ../../../../vsf/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include/: NUC505Series.h
  group vsf/hal/driver/ST
    ../../../../vsf/hal/driver/ST/: driver.h
  group vsf/hal/driver/ST/STM32F730
    ../../../../vsf/hal/driver/ST/STM32F730/: __device.h
  group vsf/hal/driver/ST/STM32F730/common
    ../../../../vsf/hal/driver/ST/STM32F730/common/: __common.c __common.h
  group vsf/hal/driver/ST/STM32F730/common/vendor/Include
    ../../../../vsf/hal/driver/ST/STM32F730/common/vendor/Include/: stm32f730xx.h
  group vsf/hal/driver/ST/STM32F730/STM32F730R8
    ../../../../vsf/hal/driver/ST/STM32F730/STM32F730R8/: device.h driver.c driver.h startup_STM32F730R8.c
  group vsf/hal/driver/template
    ../../../../vsf/hal/driver/template/: driver.h
  group vsf/hal/driver/template/__series_name__/__device_name_1__
    ../../../../vsf/hal/driver/template/__series_name__/__device_name_1__/: driver.c driver.h
  group vsf/hal/driver/TI
    ../../../../vsf/hal/driver/TI/: driver.h
  group vsf/hal/driver/TI/AM335X/AM3352
    ../../../../vsf/hal/driver/TI/AM335X/AM3352/: device.h driver.c driver.h
  group vsf/hal/driver/WinnerMicro
    ../../../../vsf/hal/driver/WinnerMicro/: driver.h
  group vsf/hal/driver/WinnerMicro/W60X
    ../../../../vsf/hal/driver/WinnerMicro/W60X/: device.h
  group vsf/hal/driver/WinnerMicro/W60X/common
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/: common.c common.h
  group vsf/hal/driver/WinnerMicro/W60X/common/io
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/usart
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include/: wm_regs.h
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup/IAR/: startup_venus.s
  group vsf/hal/driver/WinnerMicro/W60X/W600
    ../../../../vsf/hal/driver/WinnerMicro/W60X/W600/: device.h driver.c driver.h
  group vsf/hal/interface
    ../../../../vsf/hal/interface/: vsf_interface_common.h vsf_interface_io.h vsf_interface_pm.h vsf_interface_usart.h vsf_interface_usb.h
  group vsf/utilities/compiler
    ../../../../vsf/utilities/compiler/arm/: arm_compiler.h type.h
  group vsf/utilities/compiler/__common
    ../../../../vsf/utilities/compiler/__common/: __compiler.h __signal.h __type.h
