# Keil uVision project Blinky.uvprojx, settings and files
target demo_armv7-m (6160000::V6.16::ARMCLANG)
  device: CMSDK_CM7 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: -fms-extensions
  c include: ..\..\..\..\source;..\..\source;..\..\..\..\source\utilities\compiler\arm\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
  group usrapp
    ../../source/: main.c user_retarget.c main_fsm_simple.c systimer_test.c vsf_usr_cfg.h main_task_simple.c main_cross_task_example.c main_thread_simple.c main_pt_simple.c main_eda_simple.c
    ./lib/: vsf_kernel.lib
    ../../source/ooc_demo/: class_demo.c class_simple_demo.c
  group vsf/hal/arch
    ../../../../source/hal/arch/arm/cortex-m/: cortex_m_generic.c
    ../../../../source/hal/arch/arm/cortex-m/SysTick/: systick.c systick_internal.c
    ../../../../source/hal/arch/: vsf_arch_abstraction.c __vsf_arch_interface.h
  group vsf/hal
    ../../../../source/hal/: vsf_hal.c
  group vsf/kernel
    ../../../../source/kernel/: vsf_eda.c vsf_os.c vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_common.h vsf_eda.h vsf_evtq.h vsf_kernel_cfg.h vsf_os.h vsf_kernel_bsp.c vsf_eda_slist_queue.c
  group vsf/kernel/task
    ../../../../source/kernel/task/: vsf_thread.c vsf_pt.h vsf_task.h vsf_fsm.h vsf_thread.h __vsf_task_common.h
  group vsf/utilities/template
    ../../../../source/utilities/template/: vsf_list.c template.h vsf_bitmap.h vsf_list.h vsf_bitmap.c vsf_queue.c
  group vsf/kernel/utilities/3rd-party/PLOOC
    ../../../../source/utilities/3rd-party/PLOOC/raw/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_simple_c90.h plooc_class_strict.h README.md
  group vsf/utilities
    ../../../../source/utilities/: ooc_class.h communicate.h
    ../../../../source/utilities/compiler/arm/: arm_compiler.h retarget_io.c vsf_stdio_lib_armv6_m_abv.a
    ../../../../source/utilities/language_extension/: code_region.c delegate.c
  group vsf/kernel/shell/simple
    ../../../../source/kernel/shell/simple/: vsf_simple.h vsf_simple_task.c vsf_simple_bmpevt.c vsf_simple_bmpevt.h
  group vsf/hal/interface
    ../../../../source/hal/interface/: vsf_interface_io.h vsf_interface_pm.h
  group vsf/kernel/shell
    ../../../../source/kernel/shell/: vsf_shell.h vsf_shell.c
  group vsf/service/pool
    ../../../../source/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service
    ../../../../source/service/: vsf_service.c vsf_service.h
  group vsf/service/heap
    ../../../../source/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/hal/driver/mps2/cmsdk_m7
    ../../../../source/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/driver/mps2/common
    ../../../../source/hal/driver/arm/mps2/common/: __common.h __common.c
  group vsf/hal/driver/mps2/cmsdk_m0
    ../../../../source/hal/driver/arm/mps2/CMSDK_CM0/: device.h driver.c driver.h startup_ARMCM0.c
  group c90_cfg
    ../../source/c90_cfg/: vsf_usr_cfg.h
  group vsf/osa_service/msg_tree
    ../../../../source/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group vsf/osa_hal/
    ../../../../source/osa_hal/: vsf_osa_hal.c vsf_osa_hal.h vsf_osa_hal_cfg.h
target template_armv7-m_ac6 (6150000::V6.15::ARMCLANG)
  device: CMSDK_CM7_DP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__ VSF_KERNEL_CFG_DEPLOY_IN_LIB_WITH_FULL_FEATURE_SET=ENABLED
  c misc: -fms-extensions  -Wno-enum-conversion -Wno-empty-body  -Wno-initializer-overrides -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target demo_armv6-m (6160000::V6.16::ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: as above
  c include: ..\..\..\..\source;..\..\source;..\..\..\..\source\utilities\compiler\arm\3rd-party\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target template_armv6-m (6130001::V6.13.1::.\ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: template +hex
  c flags: as above
  c define: _MSC_VER  __ARM__ __MPS2__ VSF_KERNEL_CFG_DEPLOY_IN_LIB_WITH_FULL_FEATURE_SET=ENABLED
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target vsf_stdio_lib (6140000::V6.14.0.2 (dev drop 2)::..\..\Program Files\ARMCompiler6.14Internal)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: vsf_stdio_lib_armv6_m_abv +hex (library)
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Blinky.sct
target demo_armv7-m_ac5 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: CMSDK_CM7 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: _MSC_VER __ARM__ __MPS2__ __OOC_DEBUG__
  c misc: --diag_suppress=64,1,381,177,111,188,186 --wchar32
  c include: ..\..\..\..\source;..\..\source\c90_cfg;..\..\..\..\source\utilities\compiler\arm\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target Test_Lib (6130001::V6.13.1::.\ARMCLANG)
  device: CMSDK_CM7 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: demo_lib +hex (library)
  c flags: as above
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: -fms-extensions  -Wno-enum-conversion -Wno-empty-body -fomit-frame-pointer -Wno-initializer-overrides -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
software components: CMSIS:CORE 5.4.0
