# Keil uVision project Blinky.uvprojx, settings and files
target demo_armv7-m-ac6 (6150000::V6.15.0.1 dev::.\ARMCompiler6.15)
  device: CMSDK_CM7 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") CLOCK(12000000) ELITTLE
  output: TGM7 +hex
  c flags: Optim=7 oTime=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__ __VSF_RELEASE__
  c misc: -fms-extensions -Wno-cast-align
  c include: ..\..\..\..\vsf;..\..\config;..\..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group usrapp/config
    ../../config/: lv_conf.h vsf_tgui_cfg.h vsf_usr_cfg.h
  group usrapp/config/vsf_usr_cfg
    ../../config/vsf_usr_cfg/: vsf_usr_cfg_mps2.h
  group usrapp/demo
    ../../demo/: fakefat32.c fakefat32.h
  group usrapp/demo/audio_demo
    ../../demo/audio_demo/: audio_demo.c
  group usrapp/demo/awtk_demo
    ../../demo/awtk_demo/: awtk_application.c awtk_assets.c awtk_demo.c
  group usrapp/demo/btstack_demo
    ../../demo/btstack_demo/: btstack_demo.c
  group usrapp/demo/commom
    ../../demo/common/: usrapp_audio_common.c usrapp_audio_common.h usrapp_common.c usrapp_common.h usrapp_net_common.c usrapp_net_common.h usrapp_ui_common.c usrapp_ui_common.h usrapp_usbd_common.c usrapp_usbd_common.h usrapp_usbh_common.c usrapp_usbh_common.h
  group usrapp/demo/cpp_demo
    ../../demo/cpp_demo/: cpp_demo.cpp
  group usrapp/demo/freetype_demo
    ../../demo/freetype_demo/: freetype_demo.c
  group usrapp/demo/json_demo
    ../../demo/json_demo/: json_demo.c
  group usrapp/demo/kernel_test
    ../../demo/kernel_test/: sem_test.c
  group usrapp/demo/linux_demo
    ../../demo/linux_demo/: libusb_demo.c linux_demo.c mount_file_demo.c
  group usrapp/demo/lvgl_demo
    ../../demo/lvgl_demo/: lvgl_application.c lvgl_demo.c
  group usrapp/demo/lwip_demo
    ../../demo/lwip_demo/: lwip_demo.c
  group usrapp/demo/nnom_demo
    ../../demo/nnom_demo/: nnom_demo.c
  group usrapp/demo/nnom_demo/model/mnist
    ../../demo/nnom_demo/model/mnist/: image.h weights.h
  group usrapp/demo/scsi_demo
    ../../demo/scsi_demo/: scsi_demo.c
  group usrapp/demo/sdl2_demo
    ../../demo/sdl2_demo/: sdl2_demo.c
  group usrapp/demo/tgui_demo
    ../../demo/tgui_demo/: tgui_main.c
  group usrapp/demo/usbh_demo
    ../../demo/usbh_demo/: usbh_demo.c
  group usrapp/demo/vsfip_demo
    ../../demo/vsfip_demo/: vsfip_demo.c
  group usrapp/demo/vsfvm_demo
    ../../demo/vsfvm_demo/: vsfvm_demo.c
  group usrapp/demo/xui_demo
    ../../demo/xui_demo/: xui_demo.c
  group usrapp/demo/tgui_demo/tgui_demo
    ../../demo/tgui_demo/tgui_demo/: tgui_custom.c tgui_custom.h tgui_demo.c tgui_port.c
  group usrapp/demo/tgui_demo/tgui_demo/images
    ../../demo/tgui_demo/tgui_demo/images/: demo_images.c demo_images.h demo_images_data.h img2c.py
  group usrapp/demo/tgui_demo/tgui_demo/stopwatch
    ../../demo/tgui_demo/tgui_demo/stopwatch/: stopwatch.c stopwatch.h
  group usrapp/demo/usbd_demo
    ../../demo/usbd_demo/: usbd_demo_cdc.c usbd_demo_msc.c usbd_demo_uvc.c
  group vsf/hal/arch
    ../../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c
    ../../../../vsf/hal/arch/arm/cortex-m/SysTick/: systick.c systick_internal.c
    ../../../../vsf/hal/arch/: vsf_arch_abstraction.c __vsf_arch_interface.h
  group vsf/hal
    ../../../../vsf/hal/: vsf_hal.c
  group vsf/kernel
    ../../../../vsf/kernel/: vsf_eda.c vsf_os.c vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_common.h vsf_eda.h vsf_evtq.h vsf_kernel_cfg.h vsf_os.h vsf_kernel_bsp.c
  group vsf/kernel/task
    ../../../../vsf/kernel/task/: vsf_thread.c vsf_pt.h vsf_task.h vsf_fsm.h vsf_thread.h __vsf_task_common.h
  group vsf/utilities/template
    ../../../../vsf/utilities/template/: vsf_list.c template.h vsf_bitmap.h vsf_list.h vsf_bitmap.c
  group vsf/kernel/utilities/3rd-party/PLOOC
    ../../../../vsf/utilities/3rd-party/PLOOC/: plooc_class_strict.h plooc_class_simple.h plooc_class.h plooc.h README.md plooc_class_black_box.h
  group vsf/utilities
    ../../../../vsf/utilities/: ooc_class.h communicate.h
    ../../../../vsf/utilities/compiler/arm/: signal.h signal.c arm_compiler.h retarget_io.c
    ../../../../vsf/utilities/language_extension/: code_region.c
  group vsf/kernel/shell/simple
    ../../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_task.c vsf_simple_bmpevt.c vsf_simple_bmpevt.h
  group vsf/hal/interface
    ../../../../vsf/hal/interface/: vsf_interface_io.h vsf_interface_pm.h
  group vsf/kernel/shell
    ../../../../vsf/kernel/shell/: vsf_shell.h vsf_shell.c
  group vsf/service
    ../../../../vsf/service/: vsf_service.c vsf_service.h
  group vsf/service/pool
    ../../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/trace
    ../../../../vsf/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/service/vsfstream
    ../../../../vsf/service/vsfstream/: vsfstream.c vsfstream.h
  group vsf/service/vsfstream/fifo_stream
    ../../../../vsf/service/vsfstream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/service/vsfstream/mem_stream
    ../../../../vsf/service/vsfstream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group vsf/service/vsfstream/block_stream
    ../../../../vsf/service/vsfstream/block_stream/: vsf_block_stream.c vsf_block_stream.h
  group vsf/service/heap
    ../../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/hal/driver/mps2/cmsdk_m0
    ../../../../vsf/hal/driver/arm/mps2/CMSDK_CM0/: device.h driver.c driver.h startup_ARMCM0.c
  group vsf/hal/driver/mps2/cmsdk_m7
    ../../../../vsf/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/driver/mps2/cmsdk_common
    ../../../../vsf/hal/driver/arm/mps2/common/: __common.c __common.h
  group vsf/component
    ../../../../vsf/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/3rd-party/littlevgl
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/: lvgl.h lv_conf_template.h
  group vsf/component/3rd-party/littlevgl/port
    ../../../../vsf/component/3rd-party/littlevgl/6.0/port/: vsf_lvgl_port.c vsf_lvgl_port.h
  group vsf/component/3rd-party/littlevgl/lvgl_core
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group vsf/component/3rd-party/littlevgl/lvgl_draw
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_basic.c lv_draw_basic.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group vsf/component/3rd-party/littlevgl/lvgl_font
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c lv_symbol_def.h
  group vsf/component/3rd-party/littlevgl/lvgl_hal
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group vsf/component/3rd-party/littlevgl/lvgl_misc
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_types.h lv_utils.c lv_utils.h
  group vsf/component/3rd-party/littlevgl/lvgl_objx
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_objx/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_preload.c lv_preload.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group vsf/component/3rd-party/littlevgl/lvgl_themes
    ../../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_nemo.c lv_theme_nemo.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h
  group vsf/component/fs
    ../../../../vsf/component/fs/: vsf_fs.c vsf_fs.h vsf_fs_cfg.h
  group vsf/component/fs/driver/fatfs
    ../../../../vsf/component/fs/driver/fatfs/: vsf_fatfs.c vsf_fatfs.h
  group vsf/component/fs/driver/malfs
    ../../../../vsf/component/fs/driver/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/fs/driver/memfs
    ../../../../vsf/component/fs/driver/memfs/: vsf_memfs.c vsf_memfs.h
  group vsf/component/fs/driver/winfs
    ../../../../vsf/component/fs/driver/winfs/: vsf_winfs.c vsf_winfs.h
  group vsf/component/mal
    ../../../../vsf/component/mal/: vsf_mal.c vsf_mal.h vsf_mal_cfg.h
  group vsf/component/mal/fakefat32_mal
    ../../../../vsf/component/mal/driver/fakefat32_mal/: vsf_fakefat32_mal.c vsf_fakefat32_mal.h
  group vsf/component/mal/file_mal
    ../../../../vsf/component/mal/driver/file_mal/: vsf_file_mal.c vsf_file_mal.h
  group vsf/component/mal/mem_mal
    ../../../../vsf/component/mal/driver/mem_mal/: vsf_mem_mal.c vsf_mem_mal.h
  group vsf/component/mal/min_mal
    ../../../../vsf/component/mal/driver/mim_mal/: vsf_mim_mal.c vsf_mim_mal.h
  group vsf/component/mal/scsi_mal
    ../../../../vsf/component/mal/driver/scsi_mal/: vsf_scsi_mal.c vsf_scsi_mal.h
  group vsf/component/scsi
    ../../../../vsf/component/scsi/: vsf_scsi.c vsf_scsi.h vsf_scsi_cfg.h
  group vsf/component/scsi/driver/mal_scsi
    ../../../../vsf/component/scsi/driver/mal_scsi/: vsf_mal_scsi.c vsf_mal_scsi.h
  group vsf/component/scsi/driver/virtual_scsi
    ../../../../vsf/component/scsi/driver/virtual_scsi/: vsf_virtual_scsi.c vsf_virtual_scsi.h
  group vsf/component/ui
    ../../../../vsf/component/ui/: vsf_ui_cfg.h
  group vsf/component/usb
    ../../../../vsf/component/usb/: vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../../../vsf/component/usb/common/: usb_ch9.h usb_ch11.h usb_common.h usb_desc.h usb_type.h
  group vsf/component/usb/common/class/CDC
    ../../../../vsf/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group vsf/component/usb/common/class/HID
    ../../../../vsf/component/usb/common/class/HID/: vsf_usb_ds4.h vsf_usb_HID.h
  group vsf/component/usb/common/class/UVC
    ../../../../vsf/component/usb/common/class/UVC/: vsf_usb_UVC.h
  group vsf/component/usb/device
    ../../../../vsf/component/usb/device/: vsf_usbd.c vsf_usbd.h
  group vsf/component/usb/device/class/CDC
    ../../../../vsf/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h
  group vsf/component/usb/device/class/HID
    ../../../../vsf/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h
  group vsf/component/usb/device/class/UVC
    ../../../../vsf/component/usb/device/class/UVC/: vsf_usbd_UVC.c vsf_usbd_UVC.h
  group vsf/component/usb/driver/otg/dwcotg
    ../../../../vsf/component/usb/driver/otg/dwcotg/: dwcotg_regs.h vsf_dwcotg_common.c vsf_dwcotg_common.h vsf_dwcotg_dcd.c vsf_dwcotg_dcd.h vsf_dwcotg_hw.h
  group vsf/osa_hal
    ../../../../vsf/osa_hal/: vsf_osa_hal.c vsf_osa_hal.h vsf_osa_hal_cfg.h
  group vsf/osa_hal/driver
    ../../../../vsf/osa_hal/driver/: driver.h
  group vsf/osa_hal/driver/customised
    ../../../../vsf/osa_hal/driver/customised/: driver.h
  group vsf/osa_hal/driver/customised/multiplex_hal
    ../../../../vsf/osa_hal/driver/customised/multiplex_hal/: driver.h vsf_multiplex_hal_common.h
  group vsf/osa_hal/driver/customised/multiplex_hal/iic
    ../../../../vsf/osa_hal/driver/customised/multiplex_hal/iic/: vsf_multiplex_iic.c vsf_multiplex_iic.h
  group vsf/osa_hal/driver/customised/multiplex_hal/spi
    ../../../../vsf/osa_hal/driver/customised/multiplex_hal/spi/: vsf_multiplex_spi.c vsf_multiplex_spi.h
  group vsf/osa_hal/driver/device_specific
    ../../../../vsf/osa_hal/driver/device_specific/: driver.h
  group vsf/osa_service
    ../../../../vsf/osa_service/: vsf_osa_service.c vsf_osa_service.h vsf_osa_service_cfg.h
  group vsf/osa_service/msg_tree
    ../../../../vsf/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
target demo_armv7-m-ac5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: TGM7 +hex
  AfterMake: copy-usb.bat
  c flags: Optim=4 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1
  c define: _MSC_VER, __Hercules__, __CMEM7__, __M7A12N0__, __OOC_DEBUG__, VSF_DRIVER_HEADER=\"./Hercules/driver.h\"
  c misc: --no_unaligned_access --diag_suppress=64,1,381,177,111,188,186 --wchar32
  c include: ..\..\..\..\vsf;..\..\config;..\..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include;..\..\..\..\vsf\hal\driver;..\..\..\..\vsf\hal\driver\Hercules\cmem7\common\Vendor\CMSIS\CME_M7;..\..\..\..\vsf\hal\driver\Hercules\cmem7\common\Vendor\Driver\inc;..\..\..\..\vsf\component\3rd-party\littlevgl\6.0\raw;..\..\..\..\vsf\component\3rd-party\littlevgl\6.0\raw\lvgl\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
