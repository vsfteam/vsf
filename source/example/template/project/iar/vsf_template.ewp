# IAR project vsf_template.ewp, settings and files
configuration vsf_template_m484 (ARM, debug)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __Nuvoton__; __M484__; __OOC_CPP__; _DLIB_FILE_DESCRIPTOR=1; LV_CONF_INCLUDE_SIMPLE; HAS_STD_MALLOC; HAS_AWTK_CONFIG; FT2_BUILD_LIBRARY
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\vsf; ..\..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; ..\..\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include; ..\..\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include; ..\..\..\..\vsf\shell\sys\linux\include; ..\..\..\..\vsf\shell\media\sdl2\include\SDL2; ..\..\..\..\vsf\component\3rd-party\btstack\raw\src; ..\..\..\..\vsf\component\3rd-party\btstack\raw\chipset; ..\..\..\..\vsf\component\3rd-party\vsfvm\raw; ..\..\..\..\vsf\component\3rd-party\nnom\raw\inc; ..\..\..\..\vsf\component\3rd-party\nnom\port; ..\..\..\..\vsf\component\3rd-party\littlevgl\6.1.2\raw; ..\..\..\..\vsf\component\3rd-party\freetype\2.10.1\port; ..\..\..\..\vsf\component\3rd-party\freetype\2.10.1\raw\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: vsf_template.hex
  ILINK.IlinkOutputFile: vsf_template_m484.out
  ILINK.IlinkIcfFile: target\M484\m480.icf
  ILINK.IlinkExtraOptions: --no_entry
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration vsf_template_f1c100s (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: __CPU_ARM9__; __Allwinner__; __F1C100S__; __OOC_CPP__; _DLIB_FILE_DESCRIPTOR=1; LV_CONF_INCLUDE_SIMPLE; HAS_STD_MALLOC; HAS_AWTK_CONFIG; FT2_BUILD_LIBRARY
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\vsf; ..\..\..\..\vsf\utilities\compiler\arm\CMSIS\Core_Legacy\Include; ..\..\..\..\vsf\shell\sys\linux\include; ..\..\..\..\vsf\shell\sys\linux\include\simple_libc; ..\..\..\..\vsf\shell\media\sdl2\include\SDL2; ..\..\..\..\vsf\component\3rd-party\btstack\raw\src; ..\..\..\..\vsf\component\3rd-party\btstack\raw\chipset; ..\..\..\..\vsf\component\3rd-party\vsfvm\raw; ..\..\..\..\vsf\component\3rd-party\nnom\raw\inc; ..\..\..\..\vsf\component\3rd-party\nnom\port; ..\..\..\..\vsf\component\3rd-party\littlevgl\6.1.2\raw; ..\..\..\..\vsf\component\3rd-party\freetype\2.10.1\port; ..\..\..\..\vsf\component\3rd-party\freetype\2.10.1\raw\include
  OBJCOPY.OOCOutputFile: vsf_template.bin
  postbuild: target\F1C100S\binary\vsf_image.exe $EXE_DIR$\vsf_template.bin
  ILINK.IlinkOutputFile: vsf_template_f1c100s.out
  ILINK.IlinkIcfFile: target\F1C100S\f1c100s_app.icf
  ILINK.IlinkProgramEntryLabel: _vector
  group usrapp/config
    ../../config/: awtk_config.h btstack_config.h lv_conf.h vsf_tgui_cfg.h vsf_usr_cfg.h
  group usrapp/demo
    ../../demo/: fakefat32.c fakefat32.h
  group usrapp/demo/audio_demo
    ../../demo/audio_demo/: audio_demo.c
  group usrapp/demo/awtk_demo
    ../../demo/awtk_demo/: awtk_application.c awtk_assets.c awtk_demo.c
  group usrapp/demo/btstack_demo
    ../../demo/btstack_demo/: btstack_demo.c
  group usrapp/demo/common
    ../../demo/common/: usrapp_audio_common.c usrapp_audio_common.h usrapp_common.c usrapp_common.h usrapp_ui_common.c usrapp_ui_common.h usrapp_usbd_common.c usrapp_usbd_common.h usrapp_usbh_common.c usrapp_usbh_common.h
  group usrapp/demo/cpp_demo
    ../../demo/cpp_demo/: cpp_demo.cpp
  group usrapp/demo/linux_demo
    ../../demo/linux_demo/: libusb_demo.c linux_demo.c mount_file_demo.c
  group usrapp/demo/lvgl_demo
    ../../demo/lvgl_demo/: lvgl_application.c lvgl_demo.c
  group usrapp/demo/nnom_demo
    ../../demo/nnom_demo/: nnom_demo.c
  group usrapp/demo/nnom_demo/model/mnist
    ../../demo/nnom_demo/model/mnist/: image.h weights.h
  group usrapp/demo/scsi_demo
    ../../demo/scsi_demo/: scsi_demo.c
  group usrapp/demo/sdl2_demo
    ../../demo/sdl2_demo/: sdl2_demo.c
  group usrapp/demo/tgui_demo
    ../../demo/tgui_demo/: tgui_main.c
  group usrapp/demo/tgui_demo/tgui_demo
    ../../demo/tgui_demo/tgui_demo/: tgui_custom.c tgui_custom.h tgui_demo.c tgui_port.c
  group usrapp/demo/tgui_demo/tgui_demo/iamges
    ../../demo/tgui_demo/tgui_demo/images/: demo_images.c demo_images.h demo_images_data.h
  group usrapp/demo/tgui_demo/tgui_demo/stopwatch
    ../../demo/tgui_demo/tgui_demo/stopwatch/: stopwatch.c stopwatch.h
  group usrapp/demo/usbd_demo
    ../../demo/usbd_demo/: usbd_demo_cdc.c usbd_demo_msc.c usbd_demo_uvc.c
  group usrapp/demo/usbh_demo
    ../../demo/usbh_demo/: usbh_demo.c
  group usrapp/demo/vsfvm_demo
    ../../demo/vsfvm_demo/: vsfvm_demo.c
  group vsf
    ../../../../vsf/: vsf.h vsf_cfg.h
  group vsf/component
    ../../../../vsf/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/3rd-party/btstack/firmware/bcm/bcm20702
    ../../../../vsf/component/3rd-party/btstack/firmware/bcm/bcm20702/: bt_firmware_image.c
  group vsf/component/3rd-party/btstack/port
    ../../../../vsf/component/3rd-party/btstack/port/: btstack_run_loop_vsf.c btstack_run_loop_vsf.h hci_dump_vsf.c hci_transport_h2_vsf.c
  group vsf/component/3rd-party/btstack/raw/chipset/bcm
    ../../../../vsf/component/3rd-party/btstack/raw/chipset/bcm/: btstack_chipset_bcm.c btstack_chipset_bcm.h btstack_chipset_bcm_download_firmware.c btstack_chipset_bcm_download_firmware.h
  group vsf/component/3rd-party/btstack/raw/chipset/csr
    ../../../../vsf/component/3rd-party/btstack/raw/chipset/csr/: btstack_chipset_csr.c
  group vsf/component/3rd-party/btstack/raw/src
    ../../../../vsf/component/3rd-party/btstack/raw/src/: ad_parser.c btstack_linked_list.c btstack_memory.c btstack_memory_pool.c btstack_run_loop.c btstack_util.c hci.c hci_cmd.c l2cap.c l2cap_signaling.c
  group vsf/component/3rd-party/btstack/raw/src/classic
    ../../../../vsf/component/3rd-party/btstack/raw/src/classic/: hid_device.c rfcomm.c sdp_server.c sdp_util.c spp_server.c
  group vsf/component/3rd-party/littlevgl/6.1.2/port
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/port/: vsf_lvgl_port.c vsf_lvgl_port.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/: lvgl.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/: lv_conf_checker.h lv_version.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src/lv_core
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/lv_core/: lv_debug.c lv_debug.h lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src/lv_draw
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/lv_draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_basic.c lv_draw_basic.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src/lv_font
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c lv_symbol_def.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src/lv_hal
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src/lv_misc
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_types.h lv_utils.c lv_utils.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src/lv_objx
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/lv_objx/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_cpicker.c lv_cpicker.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_preload.c lv_preload.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group vsf/component/3rd-party/littlevgl/6.1.2/raw/src/lv_themes
    ../../../../vsf/component/3rd-party/littlevgl/6.1.2/raw/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_nemo.c lv_theme_nemo.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h
  group vsf/component/3rd-party/lwip/1.4.1/port
    ../../../../vsf/component/3rd-party/lwip/1.4.1/port/: lwip_netdrv_adapter.c lwip_netdrv_adapter.h lwippools.h
  group vsf/component/3rd-party/lwip/1.4.1/port/arch
    ../../../../vsf/component/3rd-party/lwip/1.4.1/port/arch/: cc.h perf.h sys_arch.c sys_arch.h
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/api
    ../../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core
    ../../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv4
    ../../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv6
    ../../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/snmp
    ../../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/netif
    ../../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/netif/: etharp.c
  group vsf/component/3rd-party/nnom/port
    ../../../../vsf/component/3rd-party/nnom/port/: nnom_port.h
  group vsf/component/3rd-party/nnom/raw/inc
    ../../../../vsf/component/3rd-party/nnom/raw/inc/: nnom.h nnom_activations.h nnom_layers.h nnom_local.h nnom_out_shape.h nnom_run.h nnom_utils.h
  group vsf/component/3rd-party/nnom/raw/src
    ../../../../vsf/component/3rd-party/nnom/raw/src/: nnom.c nnom_activations.c nnom_layers.c nnom_local.c nnom_out_shape.c nnom_run.c nnom_utils.c
  group vsf/component/3rd-party/vsfvm/extension/vsf/kernel
    ../../../../vsf/component/3rd-party/vsfvm/extension/vsf/kernel/: vsfvm_ext_kernel.c vsfvm_ext_kernel.h
  group vsf/component/3rd-party/vsfvm/extension/vsf/libusb
    ../../../../vsf/component/3rd-party/vsfvm/extension/vsf/libusb/: vsfvm_ext_libusb.c vsfvm_ext_libusb.h
  group vsf/component/3rd-party/vsfvm/raw
    ../../../../vsf/component/3rd-party/vsfvm/raw/: vsf_vm.h vsf_vm_cfg.h
  group vsf/component/3rd-party/vsfvm/raw/common
    ../../../../vsf/component/3rd-party/vsfvm/raw/common/: vsfvm_bytecode.h vsfvm_common.h vsfvm_objdump.c vsfvm_objdump.h
  group vsf/component/3rd-party/vsfvm/raw/compiler
    ../../../../vsf/component/3rd-party/vsfvm/raw/compiler/: vsfvm_compiler.c vsfvm_compiler.h vsfvm_snapshot.c vsfvm_snapshot.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer
    ../../../../vsf/component/3rd-party/vsfvm/raw/compiler/lexer/: vsfvm_lexer.c vsfvm_lexer.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer/dart
    ../../../../vsf/component/3rd-party/vsfvm/raw/compiler/lexer/dart/: vsfvm_lexer_dart.c vsfvm_lexer_dart.h
  group vsf/component/3rd-party/vsfvm/raw/extension
    ../../../../vsf/component/3rd-party/vsfvm/raw/extension/: vsfvm_ext.c
  group vsf/component/3rd-party/vsfvm/raw/extension/std
    ../../../../vsf/component/3rd-party/vsfvm/raw/extension/std/: vsfvm_ext_std.c vsfvm_ext_std.h
  group vsf/component/3rd-party/vsfvm/raw/runtime
    ../../../../vsf/component/3rd-party/vsfvm/raw/runtime/: vsfvm_runtime.c vsfvm_runtime.h
  group vsf/component/av
    ../../../../vsf/component/av/: vsf_av.h vsf_av_cfg.h
  group vsf/component/av/audio
    ../../../../vsf/component/av/audio/: vsf_audio.c vsf_audio.h
  group vsf/component/av/audio/decoder/wav
    ../../../../vsf/component/av/audio/decoder/wav/: vsf_wav.c vsf_wav.h
  group vsf/component/av/audio/driver/winsound
    ../../../../vsf/component/av/audio/driver/winsound/: vsf_winsound.c vsf_winsound.h
  group vsf/component/debugger
    ../../../../vsf/component/debugger/: vsf_debugger.h vsf_debugger_cfg.h
  group vsf/component/debugger/nulink
    ../../../../vsf/component/debugger/nulink/: NuConsole.c NuConsole.h NuConsole_Config.h NuConsole_stream.c NuConsole_stream.h
  group vsf/component/debugger/segger_rtt
    ../../../../vsf/component/debugger/segger_rtt/: segger_rtt_stream.c segger_rtt_stream.h
  group vsf/component/debugger/segger_rtt/RTT
    ../../../../vsf/component/debugger/segger_rtt/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group vsf/component/fs
    ../../../../vsf/component/fs/: vsf_fs.c vsf_fs.h vsf_fs_cfg.h
  group vsf/component/fs/driver/fatfs
    ../../../../vsf/component/fs/driver/fatfs/: vsf_fatfs.c vsf_fatfs.h
  group vsf/component/fs/driver/malfs
    ../../../../vsf/component/fs/driver/malfs/: vsf_malfs.c vsf_malfs.h
  group vsf/component/fs/driver/memfs
    ../../../../vsf/component/fs/driver/memfs/: vsf_memfs.c vsf_memfs.h
  group vsf/component/fs/driver/winfs
    ../../../../vsf/component/fs/driver/winfs/: vsf_winfs.c vsf_winfs.h
  group vsf/component/input
    ../../../../vsf/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h
  group vsf/component/input/driver/ds4
    ../../../../vsf/component/input/driver/ds4/: vsf_input_ds4.c vsf_input_ds4.h
  group vsf/component/input/driver/hid
    ../../../../vsf/component/input/driver/hid/: vsf_input_hid.c vsf_input_hid.h
  group vsf/component/input/driver/nspro
    ../../../../vsf/component/input/driver/nspro/: vsf_input_nspro.c vsf_input_nspro.h
  group vsf/component/input/driver/xb1
    ../../../../vsf/component/input/driver/xb1/: vsf_input_xb1.c vsf_input_xb1.h
  group vsf/component/input/driver/xb360
    ../../../../vsf/component/input/driver/xb360/: vsf_input_xb360.c vsf_input_xb360.h
  group vsf/component/input/protocol
    ../../../../vsf/component/input/protocol/: vsf_input_gamepad.h vsf_input_keyboard.h vsf_input_mouse.h vsf_input_sensor.h vsf_input_touchscreen.h
  group vsf/component/mal
    ../../../../vsf/component/mal/: vsf_mal.c vsf_mal.h vsf_mal_cfg.h
  group vsf/component/mal/driver/fakefat32_mal
    ../../../../vsf/component/mal/driver/fakefat32_mal/: vsf_fakefat32_mal.c vsf_fakefat32_mal.h
  group vsf/component/mal/driver/file_mal
    ../../../../vsf/component/mal/driver/file_mal/: vsf_file_mal.c vsf_file_mal.h
  group vsf/component/mal/driver/mem_mal
    ../../../../vsf/component/mal/driver/mem_mal/: vsf_mem_mal.c vsf_mem_mal.h
  group vsf/component/mal/driver/mim_mal
    ../../../../vsf/component/mal/driver/mim_mal/: vsf_mim_mal.c vsf_mim_mal.h
  group vsf/component/mal/driver/scsi_mal
    ../../../../vsf/component/mal/driver/scsi_mal/: vsf_scsi_mal.c vsf_scsi_mal.h
  group vsf/component/scsi
    ../../../../vsf/component/scsi/: vsf_scsi.c vsf_scsi.h vsf_scsi_cfg.h
  group vsf/component/scsi/driver/mal_scsi
    ../../../../vsf/component/scsi/driver/mal_scsi/: vsf_mal_scsi.c vsf_mal_scsi.h
  group vsf/component/scsi/driver/virtual_scsi
    ../../../../vsf/component/scsi/driver/virtual_scsi/: vsf_virtual_scsi.c vsf_virtual_scsi.h
  group vsf/component/tcpip
    ../../../../vsf/component/tcpip/: vsf_tcpip_cfg.h
  group vsf/component/tcpip/netdrv
    ../../../../vsf/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group vsf/component/ui
    ../../../../vsf/component/ui/: vsf_ui_cfg.h
  group vsf/component/ui/disp
    ../../../../vsf/component/ui/disp/: vsf_disp.c vsf_disp.h
  group vsf/component/ui/disp/driver/fb
    ../../../../vsf/component/ui/disp/driver/fb/: vsf_disp_fb.c vsf_disp_fb.h
  group vsf/component/ui/disp/driver/usbd_uvc
    ../../../../vsf/component/ui/disp/driver/usbd_uvc/: vsf_disp_usbd_uvc.c vsf_disp_usbd_uvc.h
  group vsf/component/usb
    ../../../../vsf/component/usb/: vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../../../vsf/component/usb/common/: usb_common.h usb_desc.h
  group vsf/component/usb/common/class/CDC
    ../../../../vsf/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group vsf/component/usb/common/class/HID
    ../../../../vsf/component/usb/common/class/HID/: vsf_usb_ds4.h vsf_usb_HID.h vsf_usb_nspro.h vsf_usb_xb360.h
  group vsf/component/usb/common/class/MSC
    ../../../../vsf/component/usb/common/class/MSC/: vsf_usb_MSC.h
  group vsf/component/usb/common/class/UVC
    ../../../../vsf/component/usb/common/class/UVC/: vsf_usb_UVC.h
  group vsf/component/usb/common/class/XB1
    ../../../../vsf/component/usb/common/class/XB1/: vsf_usb_xb1.h
  group vsf/component/usb/device
    ../../../../vsf/component/usb/device/: vsf_usbd.c vsf_usbd.h
  group vsf/component/usb/device/class/CDC
    ../../../../vsf/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h vsf_usbd_CDCACM_desc.h
  group vsf/component/usb/device/class/HID
    ../../../../vsf/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h
  group vsf/component/usb/device/class/MSC
    ../../../../vsf/component/usb/device/class/MSC/: vsf_usbd_MSC.c vsf_usbd_MSC.h vsf_usbd_MSC_desc.h
  group vsf/component/usb/device/class/UVC
    ../../../../vsf/component/usb/device/class/UVC/: vsf_usbd_UVC.c vsf_usbd_UVC.h
  group vsf/component/usb/driver/hcd/ohci
    ../../../../vsf/component/usb/driver/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group vsf/component/usb/driver/otg/dwcotg
    ../../../../vsf/component/usb/driver/otg/dwcotg/: dwcotg_regs.h vsf_dwcotg_common.c vsf_dwcotg_common.h vsf_dwcotg_dcd.c vsf_dwcotg_dcd.h
  group vsf/component/usb/driver/otg/musb/fdrc
    ../../../../vsf/component/usb/driver/otg/musb/fdrc/: __vsf_musb_fdrc_common.c __vsf_musb_fdrc_common.h vsf_musb_fdrc_dcd.c vsf_musb_fdrc_dcd.h
  group vsf/component/usb/host
    ../../../../vsf/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group vsf/component/usb/host/class/BTHCI
    ../../../../vsf/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group vsf/component/usb/host/class/CDC
    ../../../../vsf/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group vsf/component/usb/host/class/HID
    ../../../../vsf/component/usb/host/class/HID/: vsf_usbh_ds4.c vsf_usbh_ds4.h vsf_usbh_HID.c vsf_usbh_HID.h vsf_usbh_nspro.c vsf_usbh_nspro.h vsf_usbh_xb360.c vsf_usbh_xb360.h
  group vsf/component/usb/host/class/HUB
    ../../../../vsf/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group vsf/component/usb/host/class/libusb
    ../../../../vsf/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group vsf/component/usb/host/class/MSC
    ../../../../vsf/component/usb/host/class/MSC/: vsf_usbh_msc.c vsf_usbh_msc.h
  group vsf/component/usb/host/class/UAC
    ../../../../vsf/component/usb/host/class/UAC/: vsf_usbh_uac.c vsf_usbh_uac.h
  group vsf/component/usb/host/class/XB1
    ../../../../vsf/component/usb/host/class/XB1/: vsf_usbh_xb1.c vsf_usbh_xb1.h
  group vsf/hal
    ../../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../../vsf/hal/arch/: __vsf_arch_interface.h vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/arm/arm9
    ../../../../vsf/hal/arch/arm/arm9/: arm9_generic.c arm9_generic.h
  group vsf/hal/arch/arm/arm9/startup
    ../../../../vsf/hal/arch/arm/arm9/startup/app/asm/iar/: entry.S
  group vsf/hal/arch/arm/cortex-a
    ../../../../vsf/hal/arch/arm/cortex-a/: cortex_a_generic.c cortex_a_generic.h
  group vsf/hal/arch/arm/cortex-m
    ../../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../../../vsf/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../../../vsf/hal/driver/: driver.h
  group vsf/hal/driver/Allwinner
    ../../../../vsf/hal/driver/Allwinner/: driver.h
  group vsf/hal/driver/Allwinner/F1CX00S
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/: __device.h
  group vsf/hal/driver/Allwinner/F1CX00S/common
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/: __common.c __common.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/debug_uart
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/debug_uart/: debug_uart.c debug_uart.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/dram
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/dram/: dram.c dram.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/fb
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/fb/: fb.c fb.h
  group vsf/hal/driver/Allwinner/F1CX00S/common/usb
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/usb/: usb.c usb.h usb_common.c
  group vsf/hal/driver/Allwinner/F1CX00S/common/usb/dc
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/common/usb/dc/: usbd.c usbd.h
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/F1C100S/: device.h driver.c driver.h f1c100s_reg.h
  group vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup/asm
    ../../../../vsf/hal/driver/Allwinner/F1CX00S/F1C100S/startup/app/asm/iar/: startup.S
  group vsf/hal/driver/arm
    ../../../../vsf/hal/driver/arm/: driver.h
  group vsf/hal/driver/arm/mps2
    ../../../../vsf/hal/driver/arm/mps2/: __device.h driver.h
  group vsf/hal/driver/arm/mps2/CMSDK_CM0
    ../../../../vsf/hal/driver/arm/mps2/CMSDK_CM0/: device.h driver.c driver.h startup_ARMCM0.c
  group vsf/hal/driver/arm/mps2/CMSDK_CM7
    ../../../../vsf/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/driver/arm/mps2/common
    ../../../../vsf/hal/driver/arm/mps2/common/: __common.c __common.h
  group vsf/hal/driver/common
    ../../../../vsf/hal/driver/common/: common.h
  group vsf/hal/driver/Nuvoton
    ../../../../vsf/hal/driver/Nuvoton/: driver.h
  group vsf/hal/driver/Nuvoton/M480
    ../../../../vsf/hal/driver/Nuvoton/M480/: __device.h
  group vsf/hal/driver/Nuvoton/M480/common
    ../../../../vsf/hal/driver/Nuvoton/M480/common/: __common.c __common.h
  group vsf/hal/driver/Nuvoton/M480/common/io
    ../../../../vsf/hal/driver/Nuvoton/M480/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/pm
    ../../../../vsf/hal/driver/Nuvoton/M480/common/pm/: pm.c pm.h pm_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usart
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb/dc
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usb/dc/: usbd_hs.c usbd_hs.h
  group vsf/hal/driver/Nuvoton/M480/common/usb/ohci
    ../../../../vsf/hal/driver/Nuvoton/M480/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/Include
    ../../../../vsf/hal/driver/Nuvoton/M480/common/vendor/Include/: acmp_reg.h bpwm_reg.h can_reg.h clk_reg.h crc_reg.h crypto_reg.h dac_reg.h eadc_reg.h ebi_reg.h ecap_reg.h emac_reg.h epwm_reg.h fmc_reg.h gpio_reg.h hsotg_reg.h hsusbd_reg.h hsusbh_reg.h i2c_reg.h i2s_reg.h M480.h NuMicro.h opa_reg.h otg_reg.h pdma_reg.h qei_reg.h qspi_reg.h rtc_reg.h sc_reg.h sdh_reg.h spi_reg.h spim_reg.h sys_reg.h system_M480.h timer_reg.h uart_reg.h ui2c_reg.h usbd_reg.h usbh_reg.h uspi_reg.h uuart_reg.h wdt_reg.h wwdt_reg.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/startup
    ../../../../vsf/hal/driver/Nuvoton/M480/common/vendor/startup/IAR/: startup_M480.s.template
  group vsf/hal/driver/Nuvoton/M480/M484
    ../../../../vsf/hal/driver/Nuvoton/M480/M484/: device.h driver.c driver.h startup_M484.c
  group vsf/hal/driver/Nuvoton/NUC500
    ../../../../vsf/hal/driver/Nuvoton/NUC500/: __device.h
  group vsf/hal/driver/Nuvoton/NUC500/common/usb
    ../../../../vsf/hal/driver/Nuvoton/NUC500/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/NUC500/common/usb/ohci
    ../../../../vsf/hal/driver/Nuvoton/NUC500/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/NUC500/NUC505
    ../../../../vsf/hal/driver/Nuvoton/NUC500/NUC505/: device.h driver.c driver.h startup_NUC505.c
  group vsf/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include
    ../../../../vsf/hal/driver/Nuvoton/NUC500/NUC505/vendor/Include/: NUC505Series.h
  group vsf/hal/driver/ST
    ../../../../vsf/hal/driver/ST/: driver.h
  group vsf/hal/driver/ST/STM32F730
    ../../../../vsf/hal/driver/ST/STM32F730/: __device.h
  group vsf/hal/driver/ST/STM32F730/common
    ../../../../vsf/hal/driver/ST/STM32F730/common/: __common.c __common.h
  group vsf/hal/driver/ST/STM32F730/common/vendor/Include
    ../../../../vsf/hal/driver/ST/STM32F730/common/vendor/Include/: stm32f730xx.h
  group vsf/hal/driver/ST/STM32F730/STM32F730R8
    ../../../../vsf/hal/driver/ST/STM32F730/STM32F730R8/: device.h driver.c driver.h startup_STM32F730R8.c
  group vsf/hal/driver/template
    ../../../../vsf/hal/driver/template/: driver.h
  group vsf/hal/driver/template/__series_name__/__device_name_1__
    ../../../../vsf/hal/driver/template/__series_name__/__device_name_1__/: driver.c driver.h
  group vsf/hal/driver/TI
    ../../../../vsf/hal/driver/TI/: driver.h
  group vsf/hal/driver/TI/AM335X/AM3352
    ../../../../vsf/hal/driver/TI/AM335X/AM3352/: device.h driver.c driver.h
  group vsf/hal/driver/WinnerMicro
    ../../../../vsf/hal/driver/WinnerMicro/: driver.h
  group vsf/hal/driver/WinnerMicro/W60X
    ../../../../vsf/hal/driver/WinnerMicro/W60X/: device.h
  group vsf/hal/driver/WinnerMicro/W60X/common
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/: common.c common.h
  group vsf/hal/driver/WinnerMicro/W60X/common/io
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/usart
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include/: wm_regs.h
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup
    ../../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup/IAR/: startup_venus.s
  group vsf/hal/driver/WinnerMicro/W60X/W600
    ../../../../vsf/hal/driver/WinnerMicro/W60X/W600/: device.h driver.c driver.h
  group vsf/hal/interface
    ../../../../vsf/hal/interface/: vsf_interface_common.h vsf_interface_io.h vsf_interface_pm.h vsf_interface_usart.h vsf_interface_usb.h
  group vsf/kernel
    ../../../../vsf/kernel/: vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/__eda
    ../../../../vsf/kernel/__eda/: vsf_eda_bmpevt.c vsf_eda_queue.c vsf_eda_sync.c vsf_eda_timer.c
  group vsf/kernel/shell
    ../../../../vsf/kernel/shell/: vsf_shell.c
  group vsf/kernel/shell/simple
    ../../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmevt.c vsf_simple_task.c
  group vsf/kernel/task
    ../../../../vsf/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/osa_hal
    ../../../../vsf/osa_hal/: vsf_osa_hal.c vsf_osa_hal.h vsf_osa_hal_cfg.h
  group vsf/osa_hal/driver
    ../../../../vsf/osa_hal/driver/: driver.h
  group vsf/osa_hal/driver/customised
    ../../../../vsf/osa_hal/driver/customised/: driver.h
  group vsf/osa_hal/driver/customised/multiplex_hal
    ../../../../vsf/osa_hal/driver/customised/multiplex_hal/: driver.h vsf_multiplex_hal_common.h
  group vsf/osa_hal/driver/customised/multiplex_hal/iic
    ../../../../vsf/osa_hal/driver/customised/multiplex_hal/iic/: vsf_multiplex_iic.c vsf_multiplex_iic.h
  group vsf/osa_hal/driver/customised/multiplex_hal/spi
    ../../../../vsf/osa_hal/driver/customised/multiplex_hal/spi/: vsf_multiplex_spi.c vsf_multiplex_spi.h
  group vsf/osa_hal/driver/device_specific
    ../../../../vsf/osa_hal/driver/device_specific/: driver.h
  group vsf/osa_hal/driver/device_specific/Allwinner
    ../../../../vsf/osa_hal/driver/device_specific/Allwinner/: driver.h
  group vsf/osa_hal/driver/device_specific/Allwinner/F1CX00S/common/usb
    ../../../../vsf/osa_hal/driver/device_specific/Allwinner/F1CX00S/common/usb/: usb.h
  group vsf/osa_hal/driver/device_specific/Allwinner/F1CX00S/common/usb/hc
    ../../../../vsf/osa_hal/driver/device_specific/Allwinner/F1CX00S/common/usb/hc/: usbh.c usbh.h
  group vsf/osa_hal/driver/device_specific/Allwinner/F1CX00S/F1C100S
    ../../../../vsf/osa_hal/driver/device_specific/Allwinner/F1CX00S/F1C100S/: driver.h
  group vsf/osa_hal/sw_peripheral
    ../../../../vsf/osa_hal/sw_peripheral/: sw_periperhal_cfg.h sw_peripheral.h
  group vsf/osa_hal/sw_peripheral/io_peripheral
    ../../../../vsf/osa_hal/sw_peripheral/io_peripheral/: io_periperhal_cfg.h io_peripheral.h
  group vsf/osa_hal/sw_peripheral/io_peripheral/iic
    ../../../../vsf/osa_hal/sw_peripheral/io_peripheral/iic/: vsf_io_iic.c vsf_io_iic.h
  group vsf/osa_hal/sw_peripheral/io_peripheral/spi
    ../../../../vsf/osa_hal/sw_peripheral/io_peripheral/spi/: vsf_io_spi.c vsf_io_spi.h
  group vsf/osa_service
    ../../../../vsf/osa_service/: vsf_osa_service.c vsf_osa_service.h vsf_osa_service_cfg.h
  group vsf/osa_service/msg_tree
    ../../../../vsf/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group vsf/service
    ../../../../vsf/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/dynarr
    ../../../../vsf/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dynstack
    ../../../../vsf/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/heap
    ../../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/json
    ../../../../vsf/service/json/: vsf_json.c vsf_json.h
  group vsf/service/pbuf
    ../../../../vsf/service/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group vsf/service/pool
    ../../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/stream
    ../../../../vsf/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/stream/pbuf_queue
    ../../../../vsf/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group vsf/service/trace
    ../../../../vsf/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/service/vsfstream
    ../../../../vsf/service/vsfstream/: vsfstream.c vsfstream.h
  group vsf/service/vsfstream/fifo_stream
    ../../../../vsf/service/vsfstream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/service/vsfstream/mem_stream
    ../../../../vsf/service/vsfstream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group vsf/shell/media/sdl2
    ../../../../vsf/shell/media/sdl2/: vsf_sdl2.c vsf_sdl2_cfg.h
  group vsf/shell/media/sdl2/include
    ../../../../vsf/shell/media/sdl2/include/SDL2/: SDL.h
  group vsf/shell/sys/linux
    ../../../../vsf/shell/sys/linux/: vsf_linux.c vsf_linux.h vsf_linux_cfg.h vsf_linux_socket.c
  group vsf/shell/sys/linux/include
    ../../../../vsf/shell/sys/linux/include/: dirent.h fcntl.h libusb.h poll.h pthread.h semaphore.h signal.h stdio.h termios.h time.h unistd.h
  group vsf/shell/sys/linux/include/linux
    ../../../../vsf/shell/sys/linux/include/linux/: limits.h
  group vsf/shell/sys/linux/include/sys
    ../../../../vsf/shell/sys/linux/include/sys/: mount.h stat.h time.h types.h wait.h
  group vsf/shell/sys/linux/lib/glibc
    ../../../../vsf/shell/sys/linux/lib/glibc/: vsf_linux_glibc.c vsf_linux_glibc_pthread.c vsf_linux_glibc_sem.c vsf_linux_glibc_stdio.c vsf_linux_glibc_stdlib.c vsf_linux_glibc_time.c
  group vsf/shell/sys/linux/lib/libusb
    ../../../../vsf/shell/sys/linux/lib/libusb/: vsf_linux_libusb.c
  group vsf/shell/sys/linux/port/busybox
    ../../../../vsf/shell/sys/linux/port/busybox/: busybox.c busybox.h config.h
  group vsf/shell/sys/linux/port/busybox/shell
    ../../../../vsf/shell/sys/linux/port/busybox/shell/: vsh.c
  group vsf/utilities
    ../../../../vsf/utilities/: communicate.h compiler.h ooc_class.h
  group vsf/utilities/3rd-party/PLOOC/raw
    ../../../../vsf/utilities/3rd-party/PLOOC/raw/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_simple_c90.h plooc_class_strict.h
  group vsf/utilities/compiler
    ../../../../vsf/utilities/compiler/arm/: arm_compiler.h retarget_io.c signal.c signal.h type.h
  group vsf/utilities/compiler/__common
    ../../../../vsf/utilities/compiler/__common/: __compiler.h __retarget_io.c __signal.h __type.h
  group vsf/utilities/compiler/CMSIS/DSP/Include
    ../../../../vsf/utilities/compiler/arm/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group vsf/utilities/compiler/CMSIS/NN/Include
    ../../../../vsf/utilities/compiler/arm/CMSIS/NN/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group vsf/utilities/compiler/CMSIS/NN/source/ActivationFunctions
    ../../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q15.c arm_relu_q7.c
  group vsf/utilities/compiler/CMSIS/NN/source/ConvolutionFunctions
    ../../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c
  group vsf/utilities/compiler/CMSIS/NN/source/FullyConnectedFunctions
    ../../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s8.c
  group vsf/utilities/compiler/CMSIS/NN/source/NNSupportFunctions
    ../../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_add_q7.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_with_offset.c
  group vsf/utilities/compiler/CMSIS/NN/source/PoolingFunctions
    ../../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/PoolingFunctions/: arm_pool_q7_HWC.c
  group vsf/utilities/compiler/CMSIS/NN/source/SoftmaxFunctions
    ../../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c
  group vsf/utilities/language_extension
    ../../../../vsf/utilities/language_extension/: code_region.c code_region.h delegate.c language_extension.h simple_sprintf.c
  group vsf/utilities/preprocessor
    ../../../../vsf/utilities/preprocessor/: mf_u8_dec2str.h mrepeat.h preprocessor.h tpaste.h
  group vsf/utilities/template
    ../../../../vsf/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h vsf_queue.c vsf_queue.h
