# IAR project vsf_template.ewp, settings and files
configuration arm_mps2_m7 (ARM, debug)
  General.OGChipSelectEditMenu: CortexM7MPS2FVP Cortex-M7 MPS2 FVP
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CMSDK_CM7; __MPS2__; __ARM__; __OOC_DEBUG__
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866,Pe064
  ICCARM.CCIncludePath2: C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM7\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\; ..\..\usrapp\template; ..\..\..\vsf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vsf_template.hex
  ILINK.IlinkOutputFile: vsf_template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration kernel_template_cm7 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CMSDK_CM7; __MPS2__; __ARM__
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM7\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\; ..\..\usrapp\template; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
configuration kernel_lib_armv7m_full_size (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: CMSDK_CM7; __MPS2__; __ARM__; __VSF_LIB__
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: as above
  postbuild: C:\Keil_v5\ARM\ARMCLANG\bin\armar.exe -s kernel_lib\vsf_kernel_armv7m_full_size.a
configuration kernel_lib_armv6m_full_size (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CortexM0MPS2FVP Cortex-M0 MPS2 FVP
  General.CoreVariant: 34
  ICCARM.CCDefines: CMSDK_CM7; __MPS2__; __ARM__; __VSF_LIB__
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: as above
  postbuild: C:\Keil_v5\ARM\ARMCLANG\bin\armar.exe -s kernel_lib\vsf_kernel_armv6m_full_size.a
configuration usbh_m484 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __Nuvoton__; __M484__; __OOC_DEBUG__
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866,Pa082
  ICCARM.CCIncludePath2: ..\..\usrapp\usbh_demo; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  ILINK.IlinkIcfFile: m480.icf
  ILINK.IlinkExtraOptions: --no_entry
configuration WinnerMicro_W600 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: as above
  General.CoreVariant: 38
  ICCARM.CCDefines: __WinnerMicro__; __W600__
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.CCIncludePath2: ..\..\usrapp\w600_demo; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  ILINK.IlinkIcfFile: W600.icf
  ILINK.IlinkExtraOptions: --no_entry
configuration aio_m484 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: as above
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __Nuvoton__; __M484__
  ICCARM.CCDiagSuppress: pe301,pe128,pe381,Pe188,Pe1866,Pa082
  ICCARM.CCIncludePath2: ..\..\usrapp\aio_demo; ..\..\..\vsf; ..\..\..\vsf\component\3rd-party\btstack\raw\src; ..\..\..\vsf\component\3rd-party\btstack\raw\chipset\csr; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  ILINK.IlinkIcfFile: m480.icf
  ILINK.IlinkExtraOptions: --no_entry
  group (top)
    ../../../vsf/kernel/lib/: vsf_kernel_armv6m_full_size.a vsf_kernel_armv7m_full_size.a
  group usrapp/aio_demo
    ../../usrapp/aio_demo/: btstack_config.h main.c vsf_app_cfg.h
    ../../../vsf/component/3rd-party/btstack/raw/example/: gap_inquiry.c
  group usrapp/template
    ../../usrapp/template/: main.c user_retarget.c vsf_app_cfg.h
  group usrapp/template/ooc_demo
    ../../usrapp/template/ooc_demo/: __class_demo.h class_demo.c class_demo.h class_simple_demo.c class_simple_demo.h
  group usrapp/usbh_demo
    ../../usrapp/usbh_demo/: cdc_stream_demo.c main.c vsf_app_cfg.h
  group usrapp/w600_demo
    ../../usrapp/w600_demo/: main.c vsf_app_cfg.h
  group vsf
    ../../../vsf/: vsf.h vsf_cfg.h
  group vsf/component/3rd-party/btstack/port
    ../../../vsf/component/3rd-party/btstack/port/: btstack_run_loop_vsf.c btstack_run_loop_vsf.h hci_dump_vsf.c hci_transport_h2_vsf.c
  group vsf/component/3rd-party/btstack/raw/chipset/csr
    ../../../vsf/component/3rd-party/btstack/raw/chipset/csr/: btstack_chipset_csr.c
  group vsf/component/3rd-party/btstack/raw/src
    ../../../vsf/component/3rd-party/btstack/raw/src/: ad_parser.c btstack_linked_list.c btstack_memory.c btstack_memory_pool.c btstack_run_loop.c btstack_util.c hci.c hci_cmd.c l2cap.c l2cap_signaling.c
  group vsf/component/3rd-party/btstack/raw/src/classic
    ../../../vsf/component/3rd-party/btstack/raw/src/classic/: hid_device.c rfcomm.c sdp_server.c sdp_util.c spp_server.c
  group vsf/component/input
    ../../../vsf/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h
  group vsf/component/input/hid
    ../../../vsf/component/input/hid/: vsf_input_hid.c vsf_input_hid.h
  group vsf/component/tcpip
    ../../../vsf/component/tcpip/: vsf_tcpip_cfg.h
  group vsf/component/tcpip/netdrv
    ../../../vsf/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group vsf/component/tcpip/vsfip
    ../../../vsf/component/tcpip/vsfip/: vsfip.c vsfip.h
  group vsf/component/tcpip/vsfip/netif
    ../../../vsf/component/tcpip/vsfip/netif/: vsfip_netdrv_adapter.c vsfip_netdrv_adapter.h vsfip_netif.c vsfip_netif.h
  group vsf/component/tcpip/vsfip/netif/eth
    ../../../vsf/component/tcpip/vsfip/netif/eth/: vsfip_eth.c vsfip_eth.h
  group vsf/component/tcpip/vsfip/proto/dhcp
    ../../../vsf/component/tcpip/vsfip/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcp_common.h vsfip_dhcpc.c vsfip_dhcpc.h vsfip_dhcpd.c vsfip_dhcpd.h
  group vsf/component/usb
    ../../../vsf/component/usb/: vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../../vsf/component/usb/common/: usb_ch11.h usb_ch9.h usb_common.h usb_type.h
  group vsf/component/usb/common/class/CDC
    ../../../vsf/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group vsf/component/usb/common/class/HID
    ../../../vsf/component/usb/common/class/HID/: vsf_usb_HID.h
  group vsf/component/usb/device
    ../../../vsf/component/usb/device/: vsf_usbd.c vsf_usbd.h
  group vsf/component/usb/device/class/CDC
    ../../../vsf/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h
  group vsf/component/usb/device/class/HID
    ../../../vsf/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h
  group vsf/component/usb/host
    ../../../vsf/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group vsf/component/usb/host/class/BTHCI
    ../../../vsf/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group vsf/component/usb/host/class/CDC
    ../../../vsf/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group vsf/component/usb/host/class/HID
    ../../../vsf/component/usb/host/class/HID/: vsf_usbh_HID.c vsf_usbh_HID.h
  group vsf/component/usb/host/class/HUB
    ../../../vsf/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group vsf/component/usb/host/class/libusb
    ../../../vsf/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group vsf/component/usb/host/hcd/ohci
    ../../../vsf/component/usb/host/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group vsf/hal
    ../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../vsf/hal/arch/: vsf_arch.c vsf_arch.h vsf_arch_abstraction.h
  group vsf/hal/arch/arm/cortex-m
    ../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../../vsf/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../../vsf/hal/driver/: driver.h
  group vsf/hal/driver/arm
    ../../../vsf/hal/driver/arm/: driver.h
  group vsf/hal/driver/arm/mps2
    ../../../vsf/hal/driver/arm/mps2/: driver.h
  group vsf/hal/driver/Nuvoton
    ../../../vsf/hal/driver/Nuvoton/: driver.h
  group vsf/hal/driver/Nuvoton/M480
    ../../../vsf/hal/driver/Nuvoton/M480/: device.h
  group vsf/hal/driver/Nuvoton/M480/common
    ../../../vsf/hal/driver/Nuvoton/M480/common/: common.c common.h
  group vsf/hal/driver/Nuvoton/M480/common/io
    ../../../vsf/hal/driver/Nuvoton/M480/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/pm
    ../../../vsf/hal/driver/Nuvoton/M480/common/pm/: pm.c pm.h pm_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usart
    ../../../vsf/hal/driver/Nuvoton/M480/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb
    ../../../vsf/hal/driver/Nuvoton/M480/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb/dc
    ../../../vsf/hal/driver/Nuvoton/M480/common/usb/dc/: usbd_hs.c usbd_hs.h
  group vsf/hal/driver/Nuvoton/M480/common/usb/ohci
    ../../../vsf/hal/driver/Nuvoton/M480/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/Include
    ../../../vsf/hal/driver/Nuvoton/M480/common/vendor/Include/: acmp_reg.h bpwm_reg.h can_reg.h clk_reg.h crc_reg.h crypto_reg.h dac_reg.h eadc_reg.h ebi_reg.h ecap_reg.h emac_reg.h epwm_reg.h fmc_reg.h gpio_reg.h hsotg_reg.h hsusbd_reg.h hsusbh_reg.h i2c_reg.h i2s_reg.h M480.h NuMicro.h opa_reg.h otg_reg.h pdma_reg.h qei_reg.h qspi_reg.h rtc_reg.h sc_reg.h sdh_reg.h spi_reg.h spim_reg.h sys_reg.h system_M480.h timer_reg.h uart_reg.h ui2c_reg.h usbd_reg.h usbh_reg.h uspi_reg.h uuart_reg.h wdt_reg.h wwdt_reg.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/startup
    ../../../vsf/hal/driver/Nuvoton/M480/common/vendor/startup/IAR/: startup_M480.s
  group vsf/hal/driver/Nuvoton/M480/M484
    ../../../vsf/hal/driver/Nuvoton/M480/M484/: device.h driver.c driver.h
  group vsf/hal/driver/Nuvoton/NuConsole
    ../../../vsf/hal/driver/Nuvoton/NuConsole/: NuConsole.c NuConsole.h NuConsole_Config.h NuConsole_stream.c
  group vsf/hal/driver/template
    ../../../vsf/hal/driver/template/: driver.h
  group vsf/hal/driver/template/__series_name__/__device_name_1__
    ../../../vsf/hal/driver/template/__series_name__/__device_name_1__/: driver.c driver.h
  group vsf/hal/driver/WinnerMicro
    ../../../vsf/hal/driver/WinnerMicro/: driver.h
  group vsf/hal/driver/WinnerMicro/W60X
    ../../../vsf/hal/driver/WinnerMicro/W60X/: device.h
  group vsf/hal/driver/WinnerMicro/W60X/common
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/: common.c common.h
  group vsf/hal/driver/WinnerMicro/W60X/common/io
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/usart
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include/: wm_regs.h
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup/IAR/: startup_venus.s
  group vsf/hal/driver/WinnerMicro/W60X/W600
    ../../../vsf/hal/driver/WinnerMicro/W60X/W600/: device.h driver.c driver.h
  group vsf/hal/interface
    ../../../vsf/hal/interface/: vsf_interface_io.h vsf_interface_pm.h vsf_interface_usb.h
  group vsf/kernel
    ../../../vsf/kernel/: vsf_eda.c vsf_eda.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/shell
    ../../../vsf/kernel/shell/: vsf_shell.c
  group vsf/kernel/shell/simple
    ../../../vsf/kernel/shell/simple/: vsf_simple_bmevt.c vsf_simple_task.c
  group vsf/kernel/task
    ../../../vsf/kernel/task/: vsf_fsm.h vsf_pt.h vsf_task.c vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/service
    ../../../vsf/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/dynarr
    ../../../vsf/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dynstack
    ../../../vsf/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/heap
    ../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/json
    ../../../vsf/service/json/: vsf_json.c vsf_json.h
  group vsf/service/pool
    ../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/stream
    ../../../vsf/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/stream/pbuf
    ../../../vsf/service/stream/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group vsf/service/stream/pbuf_queue
    ../../../vsf/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group vsf/service/trace
    ../../../vsf/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/service/vsfstream
    ../../../vsf/service/vsfstream/: vsfstream.c vsfstream.h
  group vsf/service/vsfstream/fifo_stream
    ../../../vsf/service/vsfstream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/utilities
    ../../../vsf/utilities/: communicate.h compiler.h ooc_class.h type.h
  group vsf/utilities/3rd-party/PLOOC
    ../../../vsf/utilities/3rd-party/PLOOC/: plooc.h plooc_class.h plooc_class_simple.h plooc_class_strict.h
  group vsf/utilities/compiler
    ../../../vsf/utilities/compiler/arm/: arm_compiler.h retarget_io.c signal.c signal.h vsf_stdio_lib.a
  group vsf/utilities/preprocessor
    ../../../vsf/utilities/preprocessor/: mrepeat.h preprocessor.h tpaste.h
  group vsf/utilities/template
    ../../../vsf/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h
