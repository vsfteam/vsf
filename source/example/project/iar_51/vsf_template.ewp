# IAR project vsf_template.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: __CPU_MCS51__; __SiliconLabs__; __C8051F380__; __OOC_DEBUG__; main=__main_51__
  ICC8051.CCDiagSuppress: Pe618,Pe550,Pe301,Pe606,Pe381,Pe047,Pa082,Pe177
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\usrapp\mvc_demo_mcs51\config; ..\..\..\vsf
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration vsfvm (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: __CPU_MCS51__; __SiliconLabs__; __C8051F380__; __OOC_DEBUG__
  ICC8051.CCDiagSuppress: Pe550,Pe301,Pe606,Pe381,Pe047,Pa082,Pe177
  ICC8051.CCIncludePath2: ..\..\usrapp\vsfvm_demo; ..\..\usrapp\vsfvm_demo\config; ..\..\..\vsf; ..\..\..\vsf\component\3rd-party\vsfvm\raw
  group usrapp/kernel_test
    ../../usrapp/kernel_test_mcs51/: main.c mutex_test.c queue_test.c sem_test.c systimer_test.c vsf_usr_cfg.h
  group usrapp/mvc_demo_mcs51
    ../../usrapp/mvc_demo_mcs51/: main.c
  group usrapp/mvc_demo_mcs51/config
    ../../usrapp/mvc_demo_mcs51/config/: vsf_tgui_cfg.h vsf_usr_cfg.h
  group usrapp/mvc_demo_mcs51/tgui_demo
    ../../usrapp/mvc_demo_mcs51/tgui_demo/: tgui_demo.c tgui_port.c
  group usrapp/mvc_demo_mcs51/tgui_demo/fonts
    ../../usrapp/mvc_demo_mcs51/tgui_demo/fonts/: demo_font.c demo_font.h
  group usrapp/mvc_demo_mcs51/tgui_demo/images
    ../../usrapp/mvc_demo_mcs51/tgui_demo/images/: demo_images.c demo_images.h
  group usrapp/vsfvm
    ../../usrapp/vsfvm_demo/: main.c
  group usrapp/vsfvm/config
    ../../usrapp/vsfvm_demo/config/: btstack_config.h lv_conf.h lwipopts.h vsf_usr_cfg.h
  group vsf/component
    ../../../vsf/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/3rd-party/vsfvm/extension/vsf/kernel
    ../../../vsf/component/3rd-party/vsfvm/extension/vsf/kernel/: vsfvm_ext_kernel.c vsfvm_ext_kernel.h
  group vsf/component/3rd-party/vsfvm/raw
    ../../../vsf/component/3rd-party/vsfvm/raw/: vsf_vm.h vsf_vm_cfg.h
  group vsf/component/3rd-party/vsfvm/raw/common
    ../../../vsf/component/3rd-party/vsfvm/raw/common/: vsfvm_bytecode.h vsfvm_common.h vsfvm_objdump.c vsfvm_objdump.h
  group vsf/component/3rd-party/vsfvm/raw/compiler
    ../../../vsf/component/3rd-party/vsfvm/raw/compiler/: vsfvm_compiler.c vsfvm_compiler.h vsfvm_snapshot.c vsfvm_snapshot.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer
    ../../../vsf/component/3rd-party/vsfvm/raw/compiler/lexer/: vsfvm_lexer.c vsfvm_lexer.h
  group vsf/component/3rd-party/vsfvm/raw/compiler/lexer/dart
    ../../../vsf/component/3rd-party/vsfvm/raw/compiler/lexer/dart/: vsfvm_lexer_dart.c vsfvm_lexer_dart.h
  group vsf/component/3rd-party/vsfvm/raw/extension
    ../../../vsf/component/3rd-party/vsfvm/raw/extension/: vsfvm_ext.c
  group vsf/component/3rd-party/vsfvm/raw/extension/std
    ../../../vsf/component/3rd-party/vsfvm/raw/extension/std/: vsfvm_ext_std.c vsfvm_ext_std.h
  group vsf/component/3rd-party/vsfvm/raw/runtime
    ../../../vsf/component/3rd-party/vsfvm/raw/runtime/: vsfvm_runtime.c vsfvm_runtime.h
  group vsf/component/input
    ../../../vsf/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h vsf_input_get_type.h vsf_input_get_type_1bit.h vsf_input_get_type_4bit.h
  group vsf/component/input/protocol
    ../../../vsf/component/input/protocol/: vsf_input_gamepad.h vsf_input_keyboard.h vsf_input_mouse.h vsf_input_sensor.h vsf_input_touchscreen.h
  group vsf/component/ui
    ../../../vsf/component/ui/: vsf_ui_cfg.h
  group vsf/component/ui/disp
    ../../../vsf/component/ui/disp/: vsf_disp.c vsf_disp.h
  group vsf/component/ui/tgui
    ../../../vsf/component/ui/tgui/: vsf_tgui.c vsf_tgui.h vsf_tgui_cfg.h
  group vsf/component/ui/tgui/controls
    ../../../vsf/component/ui/tgui/controls/: __vk_tgui_slider.c __vk_tgui_slider.h __vsf_tgui_controls_common.h vsf_msg_tree_cfg.h vsf_tgui_button.c vsf_tgui_button.h vsf_tgui_control.c vsf_tgui_control.h vsf_tgui_controls.h vsf_tgui_controls_common.c vsf_tgui_label.c vsf_tgui_label.h vsf_tgui_list.c vsf_tgui_list.h vsf_tgui_panel.c vsf_tgui_panel.h vsf_tgui_text_list.c vsf_tgui_text_list.h
  group vsf/component/ui/tgui/view/simple_view
    ../../../vsf/component/ui/tgui/view/simple_view/: vsf_tgui_sv_button.c vsf_tgui_sv_button.h vsf_tgui_sv_color.c vsf_tgui_sv_color.h vsf_tgui_sv_container.c vsf_tgui_sv_container.h vsf_tgui_sv_control.c vsf_tgui_sv_control.h vsf_tgui_sv_draw.c vsf_tgui_sv_draw.h vsf_tgui_sv_font.c vsf_tgui_sv_font.h vsf_tgui_sv_label.c vsf_tgui_sv_label.h vsf_tgui_sv_list.c vsf_tgui_sv_list.h vsf_tgui_sv_panel.c vsf_tgui_sv_panel.h vsf_tgui_sv_port.h vsf_tgui_sv_style.c vsf_tgui_sv_style.h vsf_tgui_sv_text_list.c vsf_tgui_sv_text_list.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group vsf/component/ui/tgui/view/template
    ../../../vsf/component/ui/tgui/: vsf_tgui_common.c vsf_tgui_common.h
    ../../../vsf/component/ui/tgui/view/template/: vsf_tgui_v_button.c vsf_tgui_v_button.h vsf_tgui_v_container.c vsf_tgui_v_container.h vsf_tgui_v_control.c vsf_tgui_v_control.h vsf_tgui_v_label.c vsf_tgui_v_label.h vsf_tgui_v_panel.c vsf_tgui_v_panel.h vsf_tgui_v_template.h vsf_tgui_v_type.h
  group vsf/hal
    ../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../vsf/hal/arch/: vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/mcs51
    ../../../vsf/hal/arch/mcs51/: mcs51_generic.c mcs51_generic.h
  group vsf/hal/driver
    ../../../vsf/hal/driver/: driver.h
  group vsf/hal/driver/SiliconLabs
    ../../../vsf/hal/driver/SiliconLabs/: driver.h
  group vsf/hal/driver/SiliconLabs/C8051F300/C8051F380
    ../../../vsf/hal/driver/SiliconLabs/C8051F300/C8051F380/: device.h driver.c driver.h
  group vsf/hal/interface
    ../../../vsf/hal/interface/: vsf_interface_common.h vsf_interface_io.h vsf_interface_pm.h vsf_interface_usart.h vsf_interface_usb.h
  group vsf/kernel
    ../../../vsf/kernel/: vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/shell
    ../../../vsf/kernel/shell/: vsf_shell.c vsf_shell.h
  group vsf/kernel/shell/simple
    ../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmpevt.c vsf_simple_bmpevt.h vsf_simple_task.c
  group vsf/kernel/task
    ../../../vsf/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/osa_hal
    ../../../vsf/osa_hal/: vsf_osa_hal.c vsf_osa_hal.h vsf_osa_hal_cfg.h
  group vsf/osa_service
    ../../../vsf/osa_service/msg_tree/: vsf_msg_tree.c vsf_msg_tree.h
  group vsf/service
    ../../../vsf/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/dynarr
    ../../../vsf/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dynstack
    ../../../vsf/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/heap
    ../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/pool
    ../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/simple_stream
    ../../../vsf/service/simple_stream/: vsf_simple_stream.c vsf_simple_stream.h
  group vsf/service/simple_stream/block_stream
    ../../../vsf/service/simple_stream/block_stream/: vsf_block_stream.c vsf_block_stream.h
  group vsf/service/simple_stream/fifo_stream
    ../../../vsf/service/simple_stream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/service/simple_stream/mem_stream
    ../../../vsf/service/simple_stream/mem_stream/: vsf_mem_stream.c vsf_mem_stream.h
  group vsf/service/stream
    ../../../vsf/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/stream/pbuf_queue
    ../../../vsf/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group vsf/service/trace
    ../../../vsf/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/utilities
    ../../../vsf/utilities/: communicate.h compiler.h ooc_class.h
  group vsf/utilities/3rd-party/PLOOC
    ../../../vsf/utilities/3rd-party/PLOOC/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_strict.h plooc_class_strict_old.h
  group vsf/utilities/compiler
    ../../../vsf/utilities/compiler/mcs51/: mcs51_compiler.h mcs51_interrupt.c msc51_interrupt.h retarget_io.c type.h
  group vsf/utilities/compiler/__common
    ../../../vsf/utilities/compiler/__common/: __compiler.h __signal.h __type.h
  group vsf/utilities/language_extension
    ../../../vsf/utilities/language_extension/: code_region.c code_region.h language_extension.h
  group vsf/utilities/preprocessor
    ../../../vsf/utilities/preprocessor/: mf_u8_dec2str.h mrepeat.h preprocessor.h tpaste.h
  group vsf/utilities/template
    ../../../vsf/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h vsf_queue.c vsf_queue.h
