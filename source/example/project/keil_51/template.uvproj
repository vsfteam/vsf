# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F380 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: template
  c flags: Optimize=8
  c define: __CPU_MCS51__ __SiliconLabs__ __C8051F380__ __OOC_DEBUG__
  c include: ..\..\usrapp\kernel_test_mcs51;..\..\..\vsf
  group vsf_kernel
    ../../../vsf/kernel/: vsf_eda.c vsf_evtq_array.c vsf_evtq_list.c vsf_kernel_bsp.c vsf_os.c vsf_queue.c vsf_eda.h vsf_evtq.h vsf_kernel.h vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.h vsf_queue.h vsf_timq.h vsf_timq_dlist.h
  group usrapp
    ../../usrapp/kernel_test_mcs51/: main.c mutex_test.c queue_test.c sem_test.c systimer_test.c vsf_usr_cfg.h
  group utilities/compiler/51
    ../../../vsf/utilities/compiler/mcs51/: mcs51_compiler.h retarget_io.c signal.c signal.h type.h
  group hal/arch
    ../../../vsf/hal/arch/: vsf_arch_abstraction.c
    ../../../vsf/hal/arch/mcs51/: mcs51_generic.c mcs51_generic.h POST_STARTUP.A51
  group hal/driver
    ../../../vsf/hal/driver/SiliconLabs/C8051F300/C8051F380/: device.h driver.c driver.h
  group service/pool
    ../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group utilities/template
    ../../../vsf/utilities/template/: template.h vsf_list.c vsf_list.h
  group misc_to_make_compiler_happy
    ../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
    ../../../vsf/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
