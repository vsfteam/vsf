# Keil uVision project Blinky.uvprojx, settings and files
target demo_armv7-m (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: -fms-extensions -Wno-empty-body -Wno-initializer-overrides -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\..\vsf;..\..\usrapp\template;..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
  group usrapp
    ../../usrapp/template/: main.c user_retarget.c main_fsm_simple.c systimer_test.c vsf_usr_cfg.h main_task_simple.c main_pt_simple.c
    ./lib/: vsf_kernel.lib
    ../../usrapp/template/ooc_demo/: class_demo.c class_simple_demo.c
    ../iar/kernel_lib/: vsf_kernel_armv6m_full_size.a vsf_kernel_armv7m_full_size.a vsf_kernel_armv7em_full_size.a
    ../../usrapp/aio_demo/: eda_sub_demo.c
  group vsf/hal/arch
    ../../../vsf/hal/arch/: vsf_arch.c
    ../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c
    ../../../vsf/hal/arch/arm/cortex-m/SysTick/: systick.c systick_internal.c
  group vsf/hal
    ../../../vsf/hal/: vsf_hal.c
  group vsf/kernel
    ../../../vsf/kernel/: vsf_eda.c vsf_os.c vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_common.h vsf_eda.h vsf_evtq.h vsf_kernel_cfg.h vsf_os.h vsf_kernel_bsp.c
  group vsf/kernel/task
    ../../../vsf/kernel/task/: vsf_thread.c vsf_pt.h vsf_task.h vsf_fsm.h vsf_thread.h
  group vsf/utilities/template
    ../../../vsf/utilities/template/: vsf_list.c template.h vsf_bitmap.h vsf_list.h vsf_bitmap.c
  group vsf/kernel/utilities/3rd-party/PLOOC
    ../../../vsf/utilities/3rd-party/PLOOC/: plooc_class_strict.h plooc_class_simple.h plooc_class.h plooc.h README.md
  group vsf/utilities
    ../../../vsf/utilities/: ooc_class.h communicate.h compiler.h type.h
    ../../../vsf/utilities/compiler/arm/: signal.h signal.c arm_compiler.h retarget_io.c vsf_stdio_lib.a
  group vsf/kernel/shell/simple
    ../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_task.c vsf_simple_bmevt.h vsf_simple_bmevt.c
  group vsf/hal/interface
    ../../../vsf/hal/interface/: vsf_interface_io.h vsf_interface_pm.h
  group vsf/kernel/shell
    ../../../vsf/kernel/shell/: vsf_shell.h vsf_shell.c
  group vsf/service/pool
    ../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service
    ../../../vsf/service/: vsf_service.c vsf_service.h
  group vsf/service/heap
    ../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
target template_armv7-m_ac6 (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: template +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: -fms-extensions -Wno-empty-body  -Wno-initializer-overrides -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target kernel_lib (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: vsf_kernel +hex (library)
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target demo_armv6-m (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: as above
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target template_armv6-m (6120000::V6.12::.\ARMCLANG)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: template +hex
  c flags: as above
  c define: _MSC_VER  __ARM__ __MPS2__
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\Blinky.sct
target vsf_stdio_lib (6120000::V6.12::.\ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: vsf_stdio_lib +hex (library)
  c flags: as above
  c define: _MSC_VER __ARM__ __MPS2__
  c misc: as above
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Blinky.sct
software components: CMSIS:CORE 5.2.0, Board Support:Common 2.0.0, Device:Startup 1.0.0, Device:Startup 1.0.0, Device:Startup 1.0.0
