# Keil uVision project gcc_project.uvprojx, settings and files
target gcc_template (ARM-GNU)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: gcc_project +hex
  group user_app
    ../../usrapp/template/: main.c user_retarget.c
    ../../usrapp/template/ooc_demo/: class_demo.c class_simple_demo.c
  group vsf/hal/arch
    ../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c
    ../../../vsf/hal/arch/arm/cortex-m/SysTick/: systick.c systick_internal.c
    ../../../vsf/hal/arch/: vsf_arch_abstraction.c
  group vsf/hal
    ../../../vsf/hal/: vsf_hal.c
  group vsf_kernel
    ../../../vsf/kernel/: vsf_kernel_bsp.c vsf_eda.c vsf_eda.h vsf_eda_slist_queue.c vsf_eda_slist_queue.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_timq.h vsf_timq_dlist.h
    ../../../vsf/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.c vsf_task.h vsf_thread.c vsf_thread.h
    ../../../vsf/kernel/shell/: vsf_shell.c vsf_shell.h
    ../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmevt.c vsf_simple_bmevt.h vsf_simple_task.c
  group startup
    ../../../vsf/hal/driver/arm/mps2/CMSDK_CM7/: startup_ARMCM7.c
  group utilities
    ../../../vsf/utilities/language_extension/: code_region.c simple_sprintf.c simple_sscanf.c
    ../../../vsf/utilities/template/: vsf_bitmap.c vsf_list.c vsf_queue.c
    ../../../vsf/utilities/compiler/arm/: retarget_io.c signal.c
  group service
    ../../../vsf/service/: vsf_service.c
    ../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
    ../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
    ../../../vsf/service/trace/: vsf_trace.c vsf_trace.h
